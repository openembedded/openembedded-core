require abiword.inc

SRCREV = "21818"
PV="2.5.2+svnr${SRCPV}"
PR = "r0"

SRC_URI = "${SVNURI}"

S = "${SVNSRC}"

