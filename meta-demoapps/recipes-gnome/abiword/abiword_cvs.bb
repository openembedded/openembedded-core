require abiword.inc

PV="2.5.0+cvs${SRCDATE}"
PR = "r4"

SRC_URI = "${CVSURI}"

S = "${CVSSRC}"

