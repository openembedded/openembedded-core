require libopensync-plugin_0.36.inc
LICENSE = "LGPL"
