require libopensync-plugin_0.36.inc
LICENSE = "GPLv2"

DEPENDS += "openobex bluez4"
