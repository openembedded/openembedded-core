MIRRORS_append () {
ftp://.*/.*/	http://meshcube.org/nylon/stable/sources/
http://.*/.*/	http://meshcube.org/nylon/stable/sources/
ftp://.*/.*/	http://meshcube.org/nylon/unstable/sources/
http://.*/.*/	http://meshcube.org/nylon/unstable/sources/
}