PV := "${PV}"

include automake-native.inc
