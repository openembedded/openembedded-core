SECTION = "unknown"
include xext_${PV}.bb
inherit native
DEPENDS = "x11-native xextensions-native"
