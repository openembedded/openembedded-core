SECTION = "unknown"
include xextensions_${PV}.bb
inherit native
PROVIDES = ""
