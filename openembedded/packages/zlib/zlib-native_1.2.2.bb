SECTION = "libs"
include zlib_${PV}.bb
inherit native
DEPENDS = ""
