SECTION = "unknown"
include xproto_${PV}.bb
inherit native
PROVIDES = ""
