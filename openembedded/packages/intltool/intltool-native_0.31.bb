SECTION = "devel"
include intltool_${PV}.bb
inherit native
DEPENDS = "libxml-parser-perl-native"
