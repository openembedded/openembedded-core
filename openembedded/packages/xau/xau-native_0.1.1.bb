SECTION = "x11/base"
include xau_${PV}.bb
inherit native
DEPENDS = "xproto-native"
PROVIDES = ""
