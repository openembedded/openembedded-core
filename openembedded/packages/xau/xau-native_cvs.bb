SECTION = "x11/base"
include xau_cvs.bb
inherit native
DEPENDS = "xproto-native"
PROVIDES = ""
