include ipkg.inc
PR = "r2"

SRC_URI += "file://remove-c99isms.patch;patch=1"
