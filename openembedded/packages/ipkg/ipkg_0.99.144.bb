include ipkg.inc
PR = "r2"
SRC_URI += "file://paths.patch;patch=1"
