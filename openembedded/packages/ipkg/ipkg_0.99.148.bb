include ipkg.inc
SRC_URI += "file://libdir.patch;patch=1"
