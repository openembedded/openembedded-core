DESCRIPTION = "User space helper for WPA and WPA2 client operations. \
The Supplicant is used in WPA/WPA2 key handshakes to authenticate \
with the AP and to generate dynamic encryption keys (TKIP or CCMP)."

PR = "r3"

include wpa-supplicant_${PV}.inc
