SECTION = "x11/base"
include xtrans_${PV}.bb
inherit native
