DESCRIPTION = "A Calculator for Openmoko"
SECTION = "openmoko/tools"
DEPENDS = "libmokoui2"
PV = "0.1.0+svnr${SRCREV}"
PR = "r0"

inherit openmoko2
