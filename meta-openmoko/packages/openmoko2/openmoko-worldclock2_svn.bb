DESCRIPTION = "A World-Clock for Openmoko"
SECTION = "openmoko/tools"
DEPENDS = "libmokoui2 libjana"
PV = "0.1.0+svnr${SRCREV}"

inherit openmoko2
