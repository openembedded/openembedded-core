require dates.inc

PR = "r3"

SRC_URI = "http://pimlico-project.org/sources/dates/dates-${PV}.tar.gz"
