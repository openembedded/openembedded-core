require rxvt-unicode.inc

LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504 \
                    file://src/main.C;beginline=1;endline=31;md5=d3600d7ee1062667fcd1193fbe6485f6"

SRC_URI[sha256sum] = "2f81c16bffb16f97c4633032e08a7ef08c000f81eb05853e950febc6c33328dd"

