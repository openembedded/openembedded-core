#
# Copyright (C) 2007 OpenedHand Ltd.
#

IMAGE_FEATURES += "apps-console-core ${SATO_IMAGE_FEATURES} tools-debug tools-profile tools-sdk dev-pkgs"

inherit poky-image
