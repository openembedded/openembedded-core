require matchbox-theme-sato.inc

PR = "r0"

SRC_URI = "http://pokylinux.org/releases/sato/matchbox-theme-sato-0.1.tar.gz"
