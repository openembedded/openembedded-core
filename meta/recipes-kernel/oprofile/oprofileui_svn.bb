require oprofileui-svn.inc

