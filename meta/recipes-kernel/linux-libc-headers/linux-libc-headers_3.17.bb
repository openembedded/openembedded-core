KORG_ARCHIVE_COMPRESSION = "xz"

require linux-libc-headers.inc

SRC_URI[md5sum] = "fb30d0f29214d75cddd2faa94f73d5cf"
SRC_URI[sha256sum] = "f5153ec93c5fcd41b247950e6a9bcbc63fa87beafd112c133a622439a0f76251"

