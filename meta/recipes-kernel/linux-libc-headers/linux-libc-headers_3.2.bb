require linux-libc-headers.inc

PR = "r1"

SRC_URI[md5sum] = "7ceb61f87c097fc17509844b71268935"
SRC_URI[sha256sum] = "c881fc2b53cf0da7ca4538aa44623a7de043a41f76fd5d0f51a31f6ed699d463"
