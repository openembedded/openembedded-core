KORG_ARCHIVE_COMPRESSION = "xz"

require linux-libc-headers.inc

SRC_URI[md5sum] = "59cc7d0a236b08de743d6d9421f0f2c6"
SRC_URI[sha256sum] = "a3c8e6aee912bfd2e69abf9df5a06058434a8771bcaa1784b5980bf1b5298e1c"

