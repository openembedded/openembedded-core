require linux-libc-headers.inc

PR = "r0"

SRC_URI[md5sum] = "3aefa02db55715d627ed23a01667057d"
SRC_URI[sha256sum] = "17f1256daa289dde1a0a587c9753556d37a52770f7c4efcf2666fd4796a6eacc"
