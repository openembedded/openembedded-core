require linux-libc-headers.inc

PR = "r0"

SRC_URI[md5sum] = "146af0160fc7a60cf9acf44aec13482b"
SRC_URI[sha256sum] = "a797a15d0b6228381507c14ecf4eec4a6cc5c77cfd521ba3b3e1325e85b5b16d"
