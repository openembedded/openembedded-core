require connman.inc
PR = "r0"

SRC_URI  = "http://www.kernel.org/pub/linux/network/connman/${P}.tar.bz2 \
            file://dbusperms.patch \
            file://connman "

