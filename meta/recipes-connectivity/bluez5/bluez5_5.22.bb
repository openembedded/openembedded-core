require bluez5.inc
SRC_URI[md5sum] = "fd0783c8bc524bc9b26514aad1f85814"
SRC_URI[sha256sum] = "e8b866515a18116c7048a55081be9238a51447c9448ed20997b0432b13ba0882"
