require bluez5.inc
SRC_URI[md5sum] = "2d839c0bc9f8daaa6ca32e65d7701812"
SRC_URI[sha256sum] = "12778f3b66e71eec50eeb2e652de94a2578f33b8c8bd57c981fa00adab524c8a"
