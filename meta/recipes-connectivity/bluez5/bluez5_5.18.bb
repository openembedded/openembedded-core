require bluez5.inc
SRC_URI[md5sum] = "9c71404f86287cd9441e86783be3aae1"
SRC_URI[sha256sum] = "8c8bb13db83d0de6c85def2da8dfa0a758aff595405fb57a00719ed94d558340"
