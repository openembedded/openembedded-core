require bluez5.inc

SRC_URI[md5sum] = "9bcc1d81e392e5be27fb11b1aad71abe"
SRC_URI[sha256sum] = "39360c4c58158cb1d5dcc56d34a0a676d8868ef8c82b3083fc7396be5e8c3963"

