require bluez5.inc

SRC_URI[md5sum] = "81f2ce3bc9a9ebe58ccfce6660031611"
SRC_URI[sha256sum] = "5a485837c215f3093d3a98cb412dc99e1139f88a66c8809bdf183ad5e676395f"

