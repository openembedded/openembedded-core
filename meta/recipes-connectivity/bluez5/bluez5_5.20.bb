require bluez5.inc
SRC_URI[md5sum] = "177d4551f76e5933cc467c3abc6d3796"
SRC_URI[sha256sum] = "531fbaa0a9baf7b1f76fb8fd8975c20d3cc61cdc772a39d63df1d6abfc2a7481"
