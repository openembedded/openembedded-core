require bluez5.inc
SRC_URI[md5sum] = "d5a0d05520e013f2394bf1d0bac12889"
SRC_URI[sha256sum] = "81eb073516f39ff1fa02fa40120e834f40fdb0b772f8f4153a9ab566cc0a1f4f"
