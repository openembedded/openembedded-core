require bluez5.inc

SRC_URI[md5sum] = "ce0ef43938e8bfc230f3f06d6ad02d7e"
SRC_URI[sha256sum] = "902299204b7139c913765603c7054a604570aea9e9fddb30454bd1b5e5997860"

