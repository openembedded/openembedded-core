require bluez5.inc

SRC_URI[md5sum] = "c68f8cb270110256a684403ee43b5f79"
SRC_URI[sha256sum] = "4581beedde485246b16e2b4665d60f3fe041284b5d5afc3a0a818604ad525ad3"

