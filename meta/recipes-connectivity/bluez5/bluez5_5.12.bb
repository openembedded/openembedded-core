require bluez5.inc

SRC_URI[md5sum] = "5d37e581107b3d6f91b81194a5006407"
SRC_URI[sha256sum] = "75ef574f15f356d03bd54f1a8ba26abe63bf3d1326a9fa12d63a762ddf40617e"

