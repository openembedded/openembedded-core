require bluez5.inc
SRC_URI[md5sum] = "92e29e51b361aab78cca30ef0cf8812e"
SRC_URI[sha256sum] = "487bd75697e565793bf5bc4fbd5fa6a602788313b0c694f7542b81689fc0aa87"

