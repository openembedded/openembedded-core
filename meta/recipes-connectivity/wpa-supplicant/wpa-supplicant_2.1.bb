require wpa-supplicant.inc

