require wpa-supplicant-2.0.inc

PR = "r1"

SRC_URI[md5sum] = "3be2ebfdcced52e00eda0afe2889839d"
SRC_URI[sha256sum] = "2c115609fbb5223d51381084a5c944455a8afcda81d584173ff55ba233379e09"
