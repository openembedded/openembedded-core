require wpa-supplicant-1.0.inc

PR = "r2"

SRC_URI[md5sum] = "8650f6aa23646ef634402552d0669640"
SRC_URI[sha256sum] = "91d41d473a5aafa2e25dd6577ebda975c4d4a3188850a53e31feaf7c04482b9c"
