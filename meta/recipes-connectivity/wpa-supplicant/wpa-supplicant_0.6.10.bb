require wpa-supplicant-0.6.inc

PE = "1"
PR = "r0"
