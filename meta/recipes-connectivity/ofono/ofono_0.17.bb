require ofono.inc

PR = "r0"

SRC_URI  = "http://www.kernel.org/pub/linux/network/ofono/${P}.tar.bz2 \
	          file://ofono"

