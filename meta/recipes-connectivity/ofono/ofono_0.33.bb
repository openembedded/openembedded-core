require ofono.inc

PR = "r0"

SRC_URI  = "http://www.kernel.org/pub/linux/network/ofono/${P}.tar.bz2 \
	          file://ofono"

SRC_URI[md5sum] = "001160996d0c00e7b8da575e1fff1bd1"
SRC_URI[sha256sum] = "1b7ce568e32518f404231389150cea5d4abfb19e09eaa6e7a280be2e5186c82f"
