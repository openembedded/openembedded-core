BASEPN = "gsmd"
CONFLICTNAME = "gsmd-devel"

require gsmd.inc

