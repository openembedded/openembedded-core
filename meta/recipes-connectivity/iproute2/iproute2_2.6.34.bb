require iproute2.inc

PR = "r1"

SRC_URI = "http://developer.osdl.org/dev/iproute2/download/${P}.tar.bz2 \
	   file://configure-cross.patch"
