# Include this class when you don't care what version of SPDX you get; it will
# be updated to the latest stable version that is supported
inherit improve_kernel_cve_report-spdx-3.0