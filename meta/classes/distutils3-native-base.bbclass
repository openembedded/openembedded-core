PYTHON_BASEVERSION = "3.3"

inherit distutils-native-base
