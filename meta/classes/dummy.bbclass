# An empty bbclass to facilitate dynamic inherit, include,
# and require statements.
