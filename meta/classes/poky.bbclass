MIRRORS_append () {
ftp://.*/.*    http://pokylinux.org/sources/
http://.*/.*   http://pokylinux.org/sources/
https://.*/.*   http://pokylinux.org/sources/
}
