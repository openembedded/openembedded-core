EXTRANATIVEPATH += "pigz-native gzip-native"
DEPENDS += "gzip-native"

