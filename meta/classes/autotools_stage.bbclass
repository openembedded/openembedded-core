inherit autotools

do_stage () {
	autotools_stage_all
}
