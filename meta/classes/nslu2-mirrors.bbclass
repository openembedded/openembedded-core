MIRRORS_append () {
ftp://.*/.*/	http://sources.nslu2-linux.org/sources/
http://.*/.*/	http://sources.nslu2-linux.org/sources/
}
