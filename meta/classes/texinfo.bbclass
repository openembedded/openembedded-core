# This class is inherited by recipes whose upstream packages invoke the
# texinfo utilities at build-time. This class currently does nothing.
