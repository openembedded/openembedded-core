require abiword-2.5.inc

PR = "r1"

RCONFLICTS = "abiword-embedded"
