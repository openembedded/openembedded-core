require gnome-doc-utils_${PV}.bb

inherit native

DEPENDS = "libxml2-native libxslt-native"

PR = "r0"
