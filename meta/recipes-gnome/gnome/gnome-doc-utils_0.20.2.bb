require gnome-doc-utils.inc
LIC_FILES_CHKSUM = "file://COPYING.GPL;md5=eb723b61539feef013de476e68b5c50a \
		    file://COPYING.LGPL;md5=a6f89e2100d9b6cdffcea4f398e37343 "
PR = "r1"

SRC_URI[archive.md5sum] = "920914c13c57e67616c6ff8594579786"
SRC_URI[archive.sha256sum] = "f6c0124f61b9400c63da630dd3a9ac1b738eac0058da245661ff699fad267aca"
