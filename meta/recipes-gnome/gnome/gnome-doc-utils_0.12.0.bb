require gnome-doc-utils.inc
LIC_FILES_CHKSUM = "file://COPYING.GPL;md5=eb723b61539feef013de476e68b5c50a \
		    file://COPYING.LGPL;md5=a6f89e2100d9b6cdffcea4f398e37343 "
PR = "r1"
