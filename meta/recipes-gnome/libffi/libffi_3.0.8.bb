SRC_URI = "ftp://sourceware.org/pub/libffi/libffi-3.0.8.tar.gz"

inherit autotools

BBCLASSEXTEND = "native"