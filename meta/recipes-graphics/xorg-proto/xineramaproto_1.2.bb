require xorg-proto-common.inc

LICENSE = "MIT & MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=3e397a5326c83d5d0ebf5b3f87163ac6 \
                    file://panoramiXproto.h;endline=24;md5=098e0bc089368a988092b3cbda617a57"

PR = "r1"
PE = "1"

SRC_URI[md5sum] = "a8aadcb281b9c11a91303e24cdea45f5"
SRC_URI[sha256sum] = "58e88087ceec7201d918f94d6b1247325adca2a9903fed11291b412427a7ba64"
