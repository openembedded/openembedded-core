require xorg-proto-common.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=e01e66e4b317088cf869bc98e6af4fb6"

CONFLICTS = "resourceext"
PR = "r1"
PE = "1"

SRC_URI[md5sum] = "84795594b3ebd2ee2570cf93340d152c"
SRC_URI[sha256sum] = "408d9ab067e4141d1bb844d2d0d7d26ad177567384190c32a913131cf549b36b"
