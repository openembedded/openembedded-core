require xorg-proto-common.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=a3c3499231a8035efd0e004cfbd3b72a \
                    file://dmxproto.h;endline=32;md5=ab8509955c3dd4c65fac728e1b367bc4"

PR = "r1"
PE = "1"

SRC_URI[md5sum] = "880a41720b2937e2660dcdc0d34a8791"
SRC_URI[sha256sum] = "3a882ca43a1f359e3489468e6c407fd7d56d559f8895cf096a2ec877d6c403b0"
