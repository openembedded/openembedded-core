require xorg-proto-common.inc

LICENSE = "MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=f8cdfa47489609f305b91521f3a8803f \
                    file://composite.h;endline=43;md5=11420a347713de702a1fe60949085464"

CONFLICTS = "compositeext"
PE = "1"

SRC_URI[md5sum] = "6281344d656d4e0c8e9db4918efe3d1d"
SRC_URI[sha256sum] = "6013d1ca63b2b7540f6f99977090812b899852acfbd9df123b5ebaa911e30003"
