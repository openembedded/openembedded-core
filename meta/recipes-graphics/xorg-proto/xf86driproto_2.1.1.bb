require xorg-proto-common.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=ef103b9d951e39ff7e23d386e2011fa3 \
                    file://xf86driproto.h;endline=35;md5=42be3d8e6d429ab79172572bb0cff544"

PR = "r0"
PE = "1"

SRC_URI[md5sum] = "1d716d0dac3b664e5ee20c69d34bc10e"
SRC_URI[sha256sum] = "9c4b8d7221cb6dc4309269ccc008a22753698ae9245a398a59df35f1404d661f"
