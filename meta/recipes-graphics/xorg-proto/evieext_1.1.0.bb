require xorg-proto-common.inc

DESCRIPTION = "X EVIE extension headers"

PR = "r1"
PE = "1"

LIC_FILES_CHKSUM = "file://COPYING;md5=6cf85dc8217152304ac976db1e240ebe"

SRC_URI[md5sum] = "5c74f61d6f77b2e6a083b2b31000be42"
SRC_URI[sha256sum] = "47881a52a8d9da1e41e4f028ed32a8b44f738afbead819c0a07253fdc1641885"
