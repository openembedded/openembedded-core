require xorg-proto-common.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=499be2ff387a42f84628c35f311f1502"

CONFLICTS = "xxf86vmext"

PR = "r0"
PE = "1"

SRC_URI[md5sum] = "4434894fc7d4eeb4a22e6b876d56fdaa"
SRC_URI[sha256sum] = "8f704613a5407b31c594d05cf8e053f2b05777172a44e7cd2abd8090bd2ac247"
