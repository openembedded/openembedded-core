require xorg-proto-common.inc

SUMMARY = "EvIE: X Event Interception Extension headers"

DESCRIPTION = "This package provides the wire protocol for the X Event \
Interception Extension.  This extension allows the interception of \
keyboard and mouse events."

PR = "r0"
PE = "1"

LIC_FILES_CHKSUM = "file://COPYING;md5=4db9fc6a58e873c6392eec53082d89b5"

SRC_URI[md5sum] = "98bd86a13686f65f0873070fdee6efc7"
SRC_URI[sha256sum] = "1cf74114436d99f56577a90b6438a32ba31b8128c9e63842bb179aba592733fe"
