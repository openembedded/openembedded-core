require xorg-proto-common.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=e01e66e4b317088cf869bc98e6af4fb6"

CONFLICTS = "xxf86dgaext"
PR = "r1"
PE = "1"
