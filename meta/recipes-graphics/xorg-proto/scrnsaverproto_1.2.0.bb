require xorg-proto-common.inc


LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=eed49b78b15b436c933b6b8b054e3901 \
                    file://saverproto.h;endline=26;md5=a84c0637305159f3c0ab173aaeede48d"

PR = "r1"
PE = "1"
