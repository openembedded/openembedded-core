require xorg-proto-common.inc


LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=a2363c155fd3749a8cf436ef56c3070f \
                    file://Print.h;beginline=2;endline=59;md5=1a2ee3cbfe3e38e136ff1b8477b51f4a"

PR = "r1"
PE = "1"

SRC_URI[md5sum] = "7321847a60748b4d2f1fa16db4b6ede8"
SRC_URI[sha256sum] = "f059a93188e7143dbb6cc55e31ccf81b976776aa3023bfa57f47501fd1bfd3be"
