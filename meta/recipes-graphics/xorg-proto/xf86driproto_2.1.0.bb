require xorg-proto-common.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=4641deddaa80fe7ca88e944e1fd94a94 \
                    file://xf86driproto.h;endline=35;md5=42be3d8e6d429ab79172572bb0cff544"

PR = "r1"
PE = "1"

SRC_URI[md5sum] = "309d552732666c3333d7dc63e80d042f"
SRC_URI[sha256sum] = "d23f12deffd03e582e897ed6a7df3ea7f66ee8577f0f61374dcdf2ebffdce1be"
