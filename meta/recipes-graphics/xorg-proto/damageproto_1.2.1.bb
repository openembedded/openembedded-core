require xorg-proto-common.inc

LICENSE = "MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=d5f5a2de65c3a84cbde769f07a769608 \
                    file://damagewire.h;endline=23;md5=4a4501a592dbc7de5ce89255e50d0296"

CONFLICTS = "damageext"
PR = "r0"
PE = "1"
