require xorg-proto-common.inc

LICENSE = "MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=c3e48aa9ce868c8e90f0401db41c11a2 \
                    file://FSproto.h;endline=44;md5=d2e58e27095e5ea7d4ad456ccb91986c"

PR = "r1"
PE = "1"

BBCLASSEXTEND = "native"
