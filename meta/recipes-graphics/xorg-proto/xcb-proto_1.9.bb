include xcb-proto.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=d763b081cb10c223435b01e00dc0aba7 \
                    file://src/dri2.xml;beginline=2;endline=28;md5=f8763b13ff432e8597e0d610cf598e65"


SRC_URI[md5sum] = "311817f844c45c0c3d76dd72e6560c10"
SRC_URI[sha256sum] = "895afe21793e6e26c5ce999b1900c02a5984c201d96d55cc42c182d3c3bde43c"
