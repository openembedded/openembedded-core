require clutter-1.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=4fbd65380cdd255951079008b364516c"

SRC_URI[archive.md5sum] = "873c97b825c366e13e1f281e8e1f549b"
SRC_URI[archive.sha256sum] = "a213c7859051d6d19b5550c7e433757a35aa8e2b61a43d2eae83dd87912ea8ae"

SRC_URI += "file://install-examples.patch"
