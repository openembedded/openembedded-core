require cogl.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=4fbd65380cdd255951079008b364516c"

SRC_URI = "http://source.clutter-project.org/sources/cogl/1.8/${BPN}-${PV}.tar.bz2 \
	   file://macro-versions.patch"

SRC_URI[md5sum] = "cd18c28bf3dd0008b072cb9c5eed7821"
SRC_URI[sha256sum] = "5ed9ee014367058a63d99a13e3fcc8cb8c6acb19ece00195c6df034fd8d8d8c7"
