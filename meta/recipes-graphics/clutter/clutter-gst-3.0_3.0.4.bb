require clutter-gst-3.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=4fbd65380cdd255951079008b364516c \
                    file://clutter-gst/clutter-gst.h;beginline=1;endline=24;md5=95baacba194e814c110ea3bdf25ddbf4"

SRC_URI[archive.md5sum] = "0b4283e6ccf5ee5d9f5fb635230fc714"
SRC_URI[archive.sha256sum] = "c61011732428c74923a52cc7629903bd910ecad22634d58f7b0c1dc55235162a"
