require clutter-gst-3.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=4fbd65380cdd255951079008b364516c \
                    file://clutter-gst/clutter-gst.h;beginline=1;endline=24;md5=95baacba194e814c110ea3bdf25ddbf4"

SRC_URI[archive.md5sum] = "3100f52225d8be92f57efe246943e3a2"
SRC_URI[archive.sha256sum] = "d6d5493ae57cc175deee479304569c419d2bb90de3be124e6f3350ae7e73df76"
