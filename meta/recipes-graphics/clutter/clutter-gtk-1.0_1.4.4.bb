require clutter-gtk-1.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=7fbc338309ac38fefcd64b04bb903e34"

SRC_URI[archive.md5sum] = "ef50b52ffc2a18704eb62f13dd8d6198"
SRC_URI[archive.sha256sum] = "bc3108594a01a08bb6d9b538afe995e4fd78634a8356064ee8137d87aad51b2e"
