include libxcb.inc
PR = "r2"

PACKAGES =+ "libxcb-xinerama"
