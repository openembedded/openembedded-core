require xcb-util.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://xcb-util-common.h;endline=30;md5=6c74595925fd773cc8cf387ff7bc53c7 \
                    file://reply/reply.c;endline=27;md5=f9a1d6b55bba632d349949cbf33cd635 \
                    file://aux/xcb_aux.c;endline=30;md5=ae305b9c2a38f9ba27060191046a6460 \
                    file://renderutil/xcb_renderutil.h;endline=24;md5=d0ddab3052dd4949c93cfcb0891c96df \
                    file://event/xcb_event.h;endline=27;md5=627be355aee59e1b8ade80d5bd90fad9 \
                    file://property/xcb_property.h;endline=27;md5=f5890866ee0c655c36ef1c6c738fee6b \
                    file://keysyms/keysyms.c;endline=30;md5=2f8de023ed823bb92f0b47900574ea9e \
                    file://image/xcb_pixel.h;beginline=4;endline=27;md5=48cd25ae55e7de525fe1e1a3a7672e1c"


PR = "r0"

