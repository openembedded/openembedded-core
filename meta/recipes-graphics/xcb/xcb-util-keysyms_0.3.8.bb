require xcb-util.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://keysyms/keysyms.c;endline=30;md5=2f8de023ed823bb92f0b47900574ea9e \
					"
PR = "r0"

SRC_URI[md5sum] = "c75bb20e709093580a67eaf263251b50"
SRC_URI[sha256sum] = "913d32f7afe380c580da7636ee13f2728790237bb5c03def536363f552686121"


