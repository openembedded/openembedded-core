include xcb-proto.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=d763b081cb10c223435b01e00dc0aba7 \
                    file://src/dri2.xml;beginline=2;endline=28;md5=f8763b13ff432e8597e0d610cf598e65"

PR = "r0"

SRC_URI[md5sum] = "f5d73ec841ed055f5e80535819f18400"
SRC_URI[sha256sum] = "e67eb7263f222133fb9d1de70928724bea3a448cdcd99d0fa4c63c04fc124b38"
