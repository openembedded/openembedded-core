require xcb-util.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://src/xcb_aux.c;endline=30;md5=ae305b9c2a38f9ba27060191046a6460 \
                    file://src/xcb_event.h;endline=27;md5=627be355aee59e1b8ade80d5bd90fad9"
PR = "r0"

SRC_URI[md5sum] = "8ce019c4bbf20dce246b98f177cfccff"
SRC_URI[sha256sum] = "c1eed9284750bc09352e60654df77bb585dbbe7673fdcc675e58b7f3a0b447b9"
