require libdrm.inc

SRC_URI += "file://installtests.patch "

SRC_URI[md5sum] = "d32a1d37c2546ee11fc5924abeedb23e"
SRC_URI[sha256sum] = "68d26e1fd85582f4243d66864f9b43ca4ee93662825de32b5506fc8e181ea41b"
