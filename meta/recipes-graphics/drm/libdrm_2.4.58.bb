require libdrm.inc

SRC_URI += "file://installtests.patch "

SRC_URI[md5sum] = "24213913333d72b36c16463ed92e522a"
SRC_URI[sha256sum] = "b155fae6b9c9a3b02ef8b77f58c7c219194c996a4018dc55ba66c03996a365dd"
