require xorg-util-common.inc

DESCRIPTION = "create dependencies in makefiles"
DEPENDS = "xproto util-macros"
PR = "r2"
PE = "1"
LIC_FILES_CHKSUM = "file://COPYING;md5=43a6eda34b48ee821b3b66f4f753ce4f"
BBCLASSEXTEND = "native"
