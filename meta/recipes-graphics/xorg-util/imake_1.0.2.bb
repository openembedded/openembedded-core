require xorg-util-common.inc

DESCRIPTION = "C preprocessor interface to the make utility"
DEPENDS = "util-macros"
RDEPENDS = "perl xproto"

PR = "r1"
PE = "1"
