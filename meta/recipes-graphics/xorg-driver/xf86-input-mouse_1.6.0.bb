require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- mouse input driver"

LIC_FILES_CHKSUM = "file://COPYING;md5=237eb1d1a602d29ef2af62d8fba60f19"
