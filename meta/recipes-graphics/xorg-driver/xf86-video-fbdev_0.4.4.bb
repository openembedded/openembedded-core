require xorg-driver-video.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=d8cbd99fff773f92e844948f74ef0df8"

DESCRIPTION = "X.Org X server -- fbdev display driver"


SRC_URI[md5sum] = "3931c0e19d441cc576dc088f9eb9fd73"
SRC_URI[sha256sum] = "9dd4b326498223abbfdf786089a46ea3db4fa6bbd341308eb48a9e00bc3fd51b"
