require xorg-driver-video.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=5e53d3fcadb1c23d122ad63cb099a918"

DESCRIPTION = "X.Org X server -- modesetting display driver"

SRC_URI[md5sum] = "38e64eb09cef9bdf1de400bbe9818321"
SRC_URI[sha256sum] = "2bc55f776eaee7b4e13df13238d36c4facf1cdca095a11519baf2376f5c996ac"
