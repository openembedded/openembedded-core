require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- evdev input driver"

LIC_FILES_CHKSUM = "file://COPYING;md5=fefe33b1cf0cacba0e72e3b0fa0f0e16"

PR = "r0"

SRC_URI[md5sum] = "eceb6dc517c0649b772f18708a1aade8"
SRC_URI[sha256sum] = "9dec173ac9d8d09ef5cb2f79e74471f5f3ddd108827f3e95958b623766260333"
