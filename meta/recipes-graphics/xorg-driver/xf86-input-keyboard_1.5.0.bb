require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- keyboard input driver"

LIC_FILES_CHKSUM = "file://COPYING;md5=ea2099d24ac9e316a6d4b9f20b3d4e10"

PR = "r0"

SRC_URI[md5sum] = "b74d7162db5ce7899c17927c6cfa9522"
SRC_URI[sha256sum] = "2303510e905465ebee91f22cdd75706a15afb108258bc220c7500f213de19cb0"
