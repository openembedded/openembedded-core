require xorg-driver-video.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=5e53d3fcadb1c23d122ad63cb099a918"

DESCRIPTION = "X.Org X server -- modesetting display driver"
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "d8a771d5d2d75ea9d234c6928153c08b"
SRC_URI[sha256sum] = "852f9ddb213913f75e1e65ad7ce9c6b5bc7f43a93d8087b6e59666ea4eb3d0d6"
