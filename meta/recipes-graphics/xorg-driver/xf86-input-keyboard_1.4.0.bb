require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- keyboard input driver"

LIC_FILES_CHKSUM = "file://COPYING;md5=eae2c98cbb8c60401893ff9313ff3826"

PR = "r1"

SRC_URI[md5sum] = "fd17158ffeacecc8cc670604460cb98b"
SRC_URI[sha256sum] = "842d36cfca68ddab4f2c562c73bfd43ba76de2d490d60034f0c5dd524aa6d6a5"
