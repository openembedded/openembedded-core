require xorg-driver-video.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=5e53d3fcadb1c23d122ad63cb099a918"

DESCRIPTION = "X.Org X server -- modesetting display driver"

SRC_URI[md5sum] = "1a25d6210257d4e493daf048f8b705a9"
SRC_URI[sha256sum] = "13dc349e9aa50987ab2479d27d6879cda2c1f9ad8c8d3a1422a2f53c36f047f8"
