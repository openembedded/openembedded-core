require pango.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

PR = "r0"

SRC_URI += "file://no-tests.patch"

PARALLEL_MAKE = ""
