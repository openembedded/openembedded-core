include mesa-common.inc
include mesa-${PV}.inc
include mesa-dri.inc
PR = "${INC_PR}.1"
