require xorg-lib-common.inc

DEPENDS += " virtual/libx11"
PE = "1"

XORG_PN = "liboldX"
