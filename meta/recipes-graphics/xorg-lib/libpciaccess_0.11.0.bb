DESCRIPTION = "Generic PCI access library"

require xorg-lib-common.inc

LICENSE = "MIT & MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=ad1647740bccb2315e6f6368dce05c6d"

PR = "r0"

DEPENDS += "xproto virtual/libx11"
