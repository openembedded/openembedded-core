require xcb-util.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://renderutil/glyph.c;endline=24;md5=c517c483b8d726234ec94f9169236661 \
					file://renderutil/util.c;endline=20;md5=6e0bfc44fb13298c0f4694eb70dc80d4 \
					file://renderutil/xcb_renderutil.h;md5=c8732d30d204d3b55e956489f635cefb \
					"

SRC_URI[md5sum] = "b346ff598ee093c141f836fbc0f8f721"
SRC_URI[sha256sum] = "9789a5c55728fa7bae374d9fdf1c61095869bdc68561911760879095644c7452"



