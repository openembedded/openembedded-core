require xorg-lib-common.inc

DEPENDS += "libxext windowswmproto"
PE = "1"

XORG_PN = "libWindowsWM"
