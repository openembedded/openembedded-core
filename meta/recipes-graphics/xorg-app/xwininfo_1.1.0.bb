require xorg-app-common.inc

DESCRIPTION = "window information utility for X"
LIC_FILES_CHKSUM = "file://COPYING;md5=78976cd3115f6faf615accc4e094d90e"
DEPENDS += "libxext libxmu"

PR = "r0"
PE = "0"
