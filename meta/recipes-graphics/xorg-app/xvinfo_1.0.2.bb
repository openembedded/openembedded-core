require xorg-app-common.inc

DESCRIPTION = "Print out X-Video extension adaptor information"
LIC_FILES_CHKSUM = "file://COPYING;md5=4641deddaa80fe7ca88e944e1fd94a94"
DEPENDS += " libxv"
PE = "1"
