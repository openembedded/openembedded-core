require xorg-app-common.inc

DESCRIPTION = "Server access control program for X"
LIC_FILES_CHKSUM = "file://COPYING;md5=cbe6a2ee97dc38c7265adfec5644689b"
DEPENDS += "libxmu libxau"
PR = "r0"
PE = "1"
