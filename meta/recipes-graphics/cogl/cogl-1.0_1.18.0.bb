require cogl-1.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=1b1a508d91d25ca607c83f92f3e31c84"

SRC_URI[archive.md5sum] = "994a29f5c02768367b6f035bfe456ba6"
SRC_URI[archive.sha256sum] = "a4d91ebf7e7aba362eb5c6e4ffebbf1167ff4ac87fabae104912d879a5390f5e"
