require cogl-1.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=4fbd65380cdd255951079008b364516c"

SRC_URI += "file://kms-include-stddef.h-before-drm.h.patch"

SRC_URI[archive.md5sum] = "611a61bed04354cbfffa3dc27feb6d4f"
SRC_URI[archive.sha256sum] = "75c2c4636a050fda7ee8722ce3d9c618b08799ed92bbb72b4fdff3e73b096094"
