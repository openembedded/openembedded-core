require cups.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=c5e50cb4b8f24b04636b719683a9102d"

SRC_URI[md5sum] = "5ab496a2ce27017fcdb3d7ec4818a75a"
SRC_URI[sha256sum] = "cf15b8caa9dab4638b628427ef309ab381817fc574b8e736d58680e0475cb2c8"
