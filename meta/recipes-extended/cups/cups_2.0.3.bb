require cups.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6c5a350596fba02754bd96eb6df3afd0"

SRC_URI[md5sum] = "8d98b85edbdab7ab03739c9622f570e8"
SRC_URI[sha256sum] = "bc3167048690a7379f29a37d9fbd2143cf0ca033b54eedd9333ddfc4ee258881"
