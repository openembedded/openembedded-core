require cups.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=c5e50cb4b8f24b04636b719683a9102d"

SRC_URI[md5sum] = "f06a997d4b71b81b23324e27174f93e7"
SRC_URI[sha256sum] = "315cdff436924c4efe04cb110b145fb1a6e038e2eed8445359052f86e9e95676"
