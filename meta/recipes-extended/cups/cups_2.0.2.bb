require cups.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6c5a350596fba02754bd96eb6df3afd0"

SRC_URI[md5sum] = "6e0ea72dbafcf5baaa1cf4178e71096d"
SRC_URI[sha256sum] = "858720f76b66fd0441ae2a16f7cabd9554c8c64607e28ffacf16c36c53a3b18b"
