require psmisc.inc
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=0636e73ff0215e8d672dc4c32c317bb3"
PR = "r1"

SRC_URI[md5sum] = "77737c817a40ef2c160a7194b5b64337"
SRC_URI[sha256sum] = "6bca237485a352362133792e000a3c8e367a26b0312c5c607db7c2a97717d15f"
