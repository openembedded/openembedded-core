require zip.inc

PR="r0"

# zip-2.32 still uses directory name of zip-2.30
S = "${WORKDIR}/zip30"
