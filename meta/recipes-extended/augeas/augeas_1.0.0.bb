require augeas.inc

PR = "r1"

SRC_URI[md5sum] = "82131019432ecf8102e1491610ad2dd1"
SRC_URI[sha256sum] = "31bf757c5b8197765946b3805f3793c32b03cd92a7a77ec95d37e71a1f131912"
