require augeas.inc


SRC_URI[md5sum] = "dce2f52cbd20f72c7da48e014ad48076"
SRC_URI[sha256sum] = "f4aeb28ebe0b0921920fe1c9b4c016739c25261a15de04cb97db02d669f481e0"
