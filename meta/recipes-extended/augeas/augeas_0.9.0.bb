require augeas.inc

PR = "r0"

SRC_URI[md5sum] = "5ef0ce53ce4c75f59ab2523506731084"
SRC_URI[sha256sum] = "55d2f482d02ac4cb38a80d95c53d2f73de435df7df1022827e7cba20bb4bb9b8"

