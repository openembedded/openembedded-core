require augeas.inc

PR = "r0"

SRC_URI[md5sum] = "d907943fc21c2d1db5dc8d97ec02a9e5"
SRC_URI[sha256sum] = "10be72446699fdcaad66e800bd83a74b4af4da40348eaca04effd8677c11514a"
