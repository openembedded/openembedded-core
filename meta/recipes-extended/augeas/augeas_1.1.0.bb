require augeas.inc

PR = "r1"

SRC_URI[md5sum] = "520ce983457ff9ffa3816bc41a9f328b"
SRC_URI[sha256sum] = "9d81e4228329e2d5cccb018ab06bc8b734fb2dede2c4d9b5c02303d4a690b76b"
