require augeas.inc

PR = "r0"

SRC_URI[md5sum] = "e3ddce5305a15bdb876ef7feec9214d1"
SRC_URI[sha256sum] = "02ba7b4f1d0796dff6ea5f8cc5f4949e4ba30b7fa2f36a0c8a5079f9975060d1"
