require augeas.inc

PR = "r0"

SRC_URI[md5sum] = "62d47bdc60e175f93aed3b81cb8e2785"
SRC_URI[sha256sum] = "916fef67e8eed6d1abe02433830301bd01dfc8228e9cfffb490347545155c4d7"
