require gzip.inc

PR = "r1"

NATIVE_PACKAGE_PATH_SUFFIX = "/${PN}"

BBCLASSEXTEND = "native"

SRC_URI[md5sum] = "e381b8506210c794278f5527cba0e765"
SRC_URI[sha256sum] = "d166cfd3da380da1bd535633e8890bfb5664f9e68870a611d1dc01a3e9f711ee"
