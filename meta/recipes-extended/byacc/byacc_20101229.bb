PR = "r0"
LICENSE="other-BSD"
LIC_FILES_CHKSUM = "file://package/debian/copyright;md5=4dc4c30f840a7203fb6edf20b3db849e"
require byacc.inc

SRC_URI[md5sum] = "e359702cda080c15f656a244aab132e5"
SRC_URI[sha256sum] = "67a5e4c7888bf7921949e38d4fd6eec855ec8b5a60d83f8d6f34eddb6d42a70c"
