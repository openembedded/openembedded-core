PR = "r0"
LICENSE="other-BSD"
LIC_FILES_CHKSUM = "file://package/debian/copyright;md5=4dc4c30f840a7203fb6edf20b3db849e"
require byacc.inc

SRC_URI[md5sum] = "5931a27e43102dc868745bf4dce91fb4"
SRC_URI[sha256sum] = "c172c7ed2ee2130510d4d6e134bcac791b217e4883051137690613ac011aca47"
