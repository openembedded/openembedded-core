PR = "r0"
LICENSE="other-BSD"
LIC_FILES_CHKSUM = "file://package/debian/copyright;md5=4dc4c30f840a7203fb6edf20b3db849e"
require byacc.inc

SRC_URI[md5sum] = "3063667be3bfcd844bdac9afd560954b"
SRC_URI[sha256sum] = "02bcfb9262127fe23abe2c42f02de12c3ea51a9fffc9fb82ffa3bda7289d72c1"
