require tar_${PV}.bb

inherit native

BPN = "tar"
EXTRAINSTALL = ""
