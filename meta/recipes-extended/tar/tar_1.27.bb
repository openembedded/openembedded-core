require tar.inc

LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504"

SRC_URI += "file://remove-gets.patch \
           "

SRC_URI[md5sum] = "74f51434bfb7756bd571a0f718b171ae"
SRC_URI[sha256sum] = "2238c5c63c7ecaccc962f10482d76875b45cedfed69138ed852a88e344af3c7b"
