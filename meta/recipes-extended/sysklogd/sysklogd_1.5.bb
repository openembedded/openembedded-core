require sysklogd.inc
PR = "r0"
