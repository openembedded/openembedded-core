require sysklogd.inc

SRCREV = "ad686ca86d977f9eac4cd0a0d0e9a5964a4621d3"
