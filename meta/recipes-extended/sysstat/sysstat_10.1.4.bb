require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "0a8e9f69c66fc6737e6645e22eed3275"
SRC_URI[sha256sum] = "7a39a923dbb4c50752a5b8227f4e76fbfea2b2545bd7faf9c168a5dc8e031dc9"
