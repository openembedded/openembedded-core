require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

SRC_URI[md5sum] = "27385bcb6c1e585de8ba7cb25ac67aef"
SRC_URI[sha256sum] = "ddbd07dfac47bcf0a6c2ae503bd80ad84dbed80c939d3dd333eb8453c38c337b"
