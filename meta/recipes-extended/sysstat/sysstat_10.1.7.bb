require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

SRC_URI[md5sum] = "112c8cc92114c961709d09f6afa537bd"
SRC_URI[sha256sum] = "1772c9c7431376458f3e7ba252c2dda88bbdc4b1cfc6f94f3d810e23e5fdac77"
