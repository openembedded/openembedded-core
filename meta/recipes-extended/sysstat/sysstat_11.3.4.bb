require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a23a74b3f4caf9616230789d94217acb"

SRC_URI += "file://0001-Include-needed-headers-explicitly.patch"

SRC_URI[md5sum] = "b92ea90a60eda2b16e2667e6237402b1"
SRC_URI[sha256sum] = "84231474b243eaffaf4b83e5a801085144361a1c8a50e9ea8a5d52ad269d20b1"
