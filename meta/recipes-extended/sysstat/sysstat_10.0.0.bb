require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

PR = "r1"



SRC_URI[md5sum] = "accc17cc1fa855be6b27def77dd92a0d"
SRC_URI[sha256sum] = "12b2ddb1c30a6d69a84ced8243b0745b4ab7f1a3b0048b9e1c21ac052d89cd43"
