require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

SRC_URI[md5sum] = "909135c84e36d780d501274e7450f924"
SRC_URI[sha256sum] = "236c6ac3136706019170ea55426f9ae016092214a5f27d9b2f373418e433d9df"
