require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

PR = "r1"



SRC_URI[md5sum] = "b680828159b5158094b9bf1ebad30e90"
SRC_URI[sha256sum] = "2a567a35511ddb873169ad3345f4e6a6219d39750638bf804027342ef89cb3e0"
