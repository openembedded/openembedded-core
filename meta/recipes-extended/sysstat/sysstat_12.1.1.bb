require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a23a74b3f4caf9616230789d94217acb"

SRC_URI += "file://0001-Include-needed-headers-explicitly.patch"

SRC_URI[md5sum] = "43e27a92ebb4e6650cb2362b32b9d7d0"
SRC_URI[sha256sum] = "64a286cabbf7939c32db5ca46009ae96509c85a2730905dc2f8f98ecc4a63937"
