require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "cdf66d6acd5c8cab709e07980b77ea6b"
SRC_URI[sha256sum] = "81f1fdcea991f6c4e64a7a65cd9045ec2418be3379d8a80db7dec59bb7b6d3c8"
