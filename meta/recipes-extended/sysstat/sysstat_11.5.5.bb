require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a23a74b3f4caf9616230789d94217acb"

SRC_URI += "file://0001-Include-needed-headers-explicitly.patch"

SRC_URI[md5sum] = "f6072bcfd5d2b02f033722f863171d0f"
SRC_URI[sha256sum] = "f4c5b333827cb588df1842d7a8f46947f486c95b305edbbce7565925e88e86c3"
