require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "8250cdcbc4a959c8a05e4186fbd13d84"
SRC_URI[sha256sum] = "119c7a23c5597d6d0df0b229c54984a35f357ecbd1c96da8cef4d105e8dfdacf"
