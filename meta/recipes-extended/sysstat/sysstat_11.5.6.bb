require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a23a74b3f4caf9616230789d94217acb"

SRC_URI += "file://0001-Include-needed-headers-explicitly.patch"

SRC_URI[md5sum] = "92735f1be44c676960b53ee28e3a4984"
SRC_URI[sha256sum] = "83a81e0a6c1d39a0985310dc2944ac6214c963adb4dc8af24ae03a9ae8d0f3ac"
