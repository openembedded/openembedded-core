require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

SRC_URI[md5sum] = "e08b5665956930ad12b10ed6e0a08b10"
SRC_URI[sha256sum] = "1f31c2b60cdc3d7aecd9bba589183f3c48ddd3ce8c15e75c6d09718cb7a496b6"

PR = "${INC_PR}.0"
