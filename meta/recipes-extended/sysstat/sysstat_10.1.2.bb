require sysstat.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b"

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c40626b96cc2b4cf303cbcf1efc96eba"
SRC_URI[sha256sum] = "c68bc2b4b436812f45e6d440a3ac106fa2a77c5cfc9d4ba7d4e7f9ded7bffab4"
