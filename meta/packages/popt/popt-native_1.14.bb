require popt_${PV}.bb
inherit native
