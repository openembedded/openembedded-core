require aaina.inc

PV = "0.3.0+svn${SRCDATE}"
PR = "r1"

SRC_URI = "svn://svn.o-hand.com/repos/clutter/trunk/toys;module=aaina;proto=http"

S = "${WORKDIR}/aaina"
