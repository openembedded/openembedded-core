require clutter-box2d.inc

PV = "0.0+git${SRCREV}"
PR = "r3"

SRC_URI = "git://git.clutter-project.org/clutter-box2d.git;protocol=git"

S = "${WORKDIR}/git"


