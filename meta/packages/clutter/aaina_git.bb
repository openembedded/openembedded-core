require aaina.inc

PV = "0.3.0+git${SRCREV}"

SRC_URI = "git://git.clutter-project.org/toys.git;protocol=git"

S = "${WORKDIR}/git/aaina"
