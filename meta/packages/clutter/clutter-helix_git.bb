require clutter-helix.inc

PV = "0.8.0+git${SRCPV}"
PR = "r0"

SRC_URI = "git://git.clutter-project.org/clutter-helix.git;protocol=git"

S = "${WORKDIR}/git"
