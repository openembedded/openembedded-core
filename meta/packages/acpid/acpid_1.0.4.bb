require acpid.inc
SRC_URI += "file://gcc40.patch;patch=1"
PR = "r3"

