require acpid.inc

PR = "r5"
