DESCRIPTION = "Metapackage for Matchbox suite"
LICENSE = "GPL"
DEPENDS = "matchbox-common matchbox-wm matchbox-panel-2 matchbox-desktop"
RDEPENDS = "matchbox-common matchbox-wm matchbox-panel-2 matchbox-desktop"
SECTION = "x11/wm"
PACKAGES= "${PN}"
ALLOW_EMPTY = 1
PR="r2"
