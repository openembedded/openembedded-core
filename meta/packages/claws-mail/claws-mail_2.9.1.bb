require claws-mail.inc
