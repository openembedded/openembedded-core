require xorg-proto-common.inc

CONFLICTS = "resourceext"
PR = "r1"
PE = "1"
