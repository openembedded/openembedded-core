require xorg-proto-common.inc

#DESCRIPTION = ""

#DEPENDS += " "
