require xproto_${PV}.bb

inherit sdk
