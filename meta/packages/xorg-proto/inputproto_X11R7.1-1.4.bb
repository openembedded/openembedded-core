require xorg-proto-common.inc

SRC_URI = "${XORG_MIRROR}/individual/proto/inputproto-1.4.tar.gz"
S = "${WORKDIR}/${XORG_PN}-1.4"
