require xorg-proto-common.inc

XORG_PN = "${PN}"
SRC_URI = "${XORG_MIRROR}/development/X11R7.2-RC3/proto/${XORG_PN}-7.0.9.tar.gz"
S = "${WORKDIR}/${XORG_PN}-7.0.9"


#DESCRIPTION = ""

#DEPENDS += " "
