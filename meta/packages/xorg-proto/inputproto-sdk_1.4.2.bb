require inputproto_${PV}.bb

inherit sdk
