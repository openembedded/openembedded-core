require xorg-proto-common.inc


LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=a2363c155fd3749a8cf436ef56c3070f \
                    file://Print.h;beginline=2;endline=59;md5=1a2ee3cbfe3e38e136ff1b8477b51f4a"

PR = "r1"
PE = "1"
