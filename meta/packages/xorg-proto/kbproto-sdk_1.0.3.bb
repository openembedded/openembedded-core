require kbproto_${PV}.bb

inherit sdk
