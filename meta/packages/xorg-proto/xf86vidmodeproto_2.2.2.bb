require xorg-proto-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

CONFLICTS = "xxf86vmext"
PE = "1"
