SECTION = "unknown"
require xproto_cvs.bb
inherit native
PROVIDES = ""
