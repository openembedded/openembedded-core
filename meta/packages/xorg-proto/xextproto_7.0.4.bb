require xorg-proto-common.inc

PR = "r2"
PE = "1"

BBCLASSEXTEND = "native sdk"
