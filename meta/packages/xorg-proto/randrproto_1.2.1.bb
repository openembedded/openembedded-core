require xorg-proto-common.inc

CONFLICTS = "randrext"
PR = "r1"
PE = "1"
