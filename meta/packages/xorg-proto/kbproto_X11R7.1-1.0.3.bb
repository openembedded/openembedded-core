require xorg-proto-common.inc

SRC_URI = "${XORG_MIRROR}/individual/proto/${XORG_PN}-1.0.3.tar.bz2"
S = "${WORKDIR}/${XORG_PN}-1.0.3"

#DESCRIPTION = ""

#DEPENDS += " "
