require kbproto_${PV}.bb

PR = "r1"

XORG_PN = "kbproto"

inherit native
