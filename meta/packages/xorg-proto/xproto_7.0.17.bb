require xorg-proto-common.inc

LICENSE = "MIT & MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=70c104816b85de375ba1fc09199d0e69"

PR = "r0"
PE = "1"

BBCLASSEXTEND = "native nativesdk"
