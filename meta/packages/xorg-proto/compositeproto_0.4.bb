require xorg-proto-common.inc

LICENSE = "MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=f8cdfa47489609f305b91521f3a8803f \
                    file://composite.h;endline=43;md5=11420a347713de702a1fe60949085464"

CONFLICTS = "compositeext"
PE = "1"
