require inputproto_${PV}.bb

PR = "r1"

XORG_PN = "inputproto"

inherit native
