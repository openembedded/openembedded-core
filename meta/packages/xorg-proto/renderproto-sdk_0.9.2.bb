require renderproto_${PV}.bb

inherit native
