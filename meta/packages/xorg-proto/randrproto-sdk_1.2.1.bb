require randrproto_${PV}.bb

inherit native
