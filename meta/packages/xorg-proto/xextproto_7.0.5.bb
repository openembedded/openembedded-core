require xorg-proto-common.inc

PR = "r3"
PE = "1"

DEPENDS += "util-macros gettext"

BBCLASSEXTEND = "native nativesdk"
