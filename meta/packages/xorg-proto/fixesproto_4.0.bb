require xorg-proto-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

CONFLICTS = "fixesext"
PE = "1"
