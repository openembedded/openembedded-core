require xproto_${PV}.bb

inherit native
