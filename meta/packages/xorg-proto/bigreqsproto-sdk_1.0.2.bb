require bigreqsproto_${PV}.bb

inherit sdk
