require xorg-proto-common.inc

PR = "r1"
PE = "1"

DEPENDS += "util-macros"

BBCLASSEXTEND = "native nativesdk"
