require xextproto_${PV}.bb

inherit native
