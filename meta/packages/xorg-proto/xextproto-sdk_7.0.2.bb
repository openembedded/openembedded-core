require xextproto_${PV}.bb

inherit sdk
