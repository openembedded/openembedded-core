require xorg-proto-common.inc

DESCRIPTION = "X EVIE extension headers"

PR = "r1"
PE = "1"

LIC_FILES_CHKSUM = "file://COPYING;md5=6cf85dc8217152304ac976db1e240ebe"
