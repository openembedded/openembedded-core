require xorg-proto-common.inc

PROVIDES="xproxymngproto"
PR = "r1"
PE = "1"
