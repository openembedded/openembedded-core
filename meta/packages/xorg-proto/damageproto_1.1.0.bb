require xorg-proto-common.inc

CONFLICTS = "damageext"
PR = "r1"
PE = "1"

XORG_PN = "damageproto"
