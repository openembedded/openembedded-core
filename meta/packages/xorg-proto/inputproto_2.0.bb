require xorg-proto-common.inc

PR = "r2"
PE = "1"

DEPENDS += "util-macros gettext"

BBCLASSEXTEND = "native nativesdk"
