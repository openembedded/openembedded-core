require xorg-proto-common.inc

CONFLICTS = "xxf86dgaext"
PR = "r1"
PE = "1"
