SECTION = "unknown"
require xproto_${PV}.bb
inherit native
PROVIDES = ""
