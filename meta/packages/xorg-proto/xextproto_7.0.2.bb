require xorg-proto-common.inc

#PROVIDES = "xextensions"

#DESCRIPTION = ""

#DEPENDS += " "

PE = "1"
