require inputproto_${PV}.bb

inherit native
