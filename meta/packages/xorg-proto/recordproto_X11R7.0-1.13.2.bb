require xorg-proto-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

CONFLICTS = "recordext"
