require xcmiscproto_${PV}.bb

inherit sdk
