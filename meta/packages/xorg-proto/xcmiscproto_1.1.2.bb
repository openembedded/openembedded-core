require xorg-proto-common.inc

PR = "r2"
PE = "1"

DEPENDS += "gettext"

BBCLASSEXTEND = "native nativesdk"
