require xorg-proto-common.inc
PE = "1"

#DESCRIPTION = ""
