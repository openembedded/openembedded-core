require xf86bigfontproto_${PV}.bb

inherit sdk
