require renderproto_${PV}.bb

inherit sdk
