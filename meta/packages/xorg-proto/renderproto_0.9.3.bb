require xorg-proto-common.inc

CONFLICTS = "renderext"
PR = "r1"
PE = "1"

XORG_PN = "renderproto"
