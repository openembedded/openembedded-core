require randrproto_${PV}.bb

inherit sdk
