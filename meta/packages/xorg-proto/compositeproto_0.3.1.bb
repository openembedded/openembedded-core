require xorg-proto-common.inc

CONFLICTS = "compositeext"
PR = "r1"
PE = "1"
