require xorg-proto-common.inc

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=ba9fcd8fe6d09af9f733daccc1a21857 \
                    file://fontcacheP.h;endline=28;md5=85c80bfa96c802ee85a570862ee60214"

PR = "r1"
PE = "1"

BBCLASSEXTEND = "native"
