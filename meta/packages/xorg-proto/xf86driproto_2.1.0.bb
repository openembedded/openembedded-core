require xorg-proto-common.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=4641deddaa80fe7ca88e944e1fd94a94 \
                    file://xf86driproto.h;endline=35;md5=42be3d8e6d429ab79172572bb0cff544"

PR = "r1"
PE = "1"
