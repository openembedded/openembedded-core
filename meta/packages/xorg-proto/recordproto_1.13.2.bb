require xorg-proto-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

CONFLICTS = "recordext"
PE = "1"
