DESCRIPTION = "DRI2 extension headers"

DEPENDS += "util-macros"

require xorg-proto-common.inc
