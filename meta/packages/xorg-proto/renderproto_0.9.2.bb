require xorg-proto-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

CONFLICTS = "renderext"
PE = "1"
