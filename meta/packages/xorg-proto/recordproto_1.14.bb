require xorg-proto-common.inc

LICENSE = "MIT-style"
LIC_FILES_CHKSUM = "file://COPYING;md5=575827a0f554bbed332542976d5f3d40 \
                    file://recordproto.h;endline=19;md5=1cbb0dd45a0b060ff833901620a3e738"

CONFLICTS = "recordext"
PR = "r1"
PE = "1"
