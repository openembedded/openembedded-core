require xorg-proto-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

PE = "1"
