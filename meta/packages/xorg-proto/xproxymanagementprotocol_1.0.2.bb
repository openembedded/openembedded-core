require xorg-proto-common.inc

PROVIDES="xproxymngproto"
#DESCRIPTION = ""

#DEPENDS += " "

PE = "1"
