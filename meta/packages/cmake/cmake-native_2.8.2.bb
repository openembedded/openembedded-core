CMAKE_MAJOR_VERSION="2.8"
require cmake.inc
inherit native
PR = "r0"
