CMAKE_MAJOR_VERSION="2.6"
require cmake.inc
