require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

DEPENDS = "mkfontscale-native font-util-native"
