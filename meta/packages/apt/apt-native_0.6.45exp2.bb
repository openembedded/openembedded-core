require apt-native.inc

SRC_URI += "file://nodoc.patch;patch=1"
