SECTION = "unknown"
require xextensions_${PV}.bb
inherit native
PROVIDES = ""
