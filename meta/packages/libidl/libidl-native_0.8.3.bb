SECTION = "libs"
require libidl_${PV}.bb
inherit native

DEPENDS = "glib-2.0-native"
