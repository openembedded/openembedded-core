require cairo.inc

SRC_URI = "http://cairographics.org/releases/cairo-${PV}.tar.gz"

PR = "r0"

