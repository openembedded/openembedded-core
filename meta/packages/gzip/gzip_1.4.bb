require gzip.inc

PR = "r0"

BBCLASSEXTEND = "native"
