require xorg-app-common.inc

DESCRIPTION = "Server access control program for X"
MAINTAINER = "Rene Wagner <rw@handhelds.org>"
LICENSE = "MIT"

DEPENDS += " virtual/libx11 libxmu libxau"

