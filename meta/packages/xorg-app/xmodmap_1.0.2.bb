require xorg-app-common.inc
PE = "1"

DESCRIPTION = "utility for modifying keymaps and pointer button mappings in X"
LICENSE = "MIT"

DEPENDS += " virtual/libx11"

