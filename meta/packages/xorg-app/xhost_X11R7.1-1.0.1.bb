require xorg-app-common.inc

DESCRIPTION = "Server access control program for X"
LICENSE = "MIT"

DEPENDS += " virtual/libx11 libxmu libxau"

