require xorg-app-common.inc

DESCRIPTION = "window information utility for X"
DEPENDS += "libxext libxmuu"
