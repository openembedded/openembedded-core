require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxv virtual/libx11"

