require xorg-app-common.inc

DESCRIPTION = "Utility for modifying keymaps and pointer button mappings in X"
LICENSE = "MIT"

DEPENDS += " virtual/libx11"

