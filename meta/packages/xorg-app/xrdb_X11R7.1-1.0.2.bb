require xorg-app-common.inc

DESCRIPTION = "X server resource database utility"
MAINTAINER = "Rene Wagner <rw@handhelds.org>"
LICENSE = "xrdb"

DEPENDS += " libxmu virtual/libx11 libxext"
