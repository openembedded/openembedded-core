require xorg-app-common.inc

DESCRIPTION = "utility for modifying keymaps and pointer button mappings in X"
MAINTAINER = "Rene Wagner <rw@handhelds.org>"
LICENSE = "MIT"

DEPENDS += " virtual/libx11"

