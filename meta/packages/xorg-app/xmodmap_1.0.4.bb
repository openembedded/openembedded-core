require xorg-app-common.inc

DESCRIPTION = "utility for modifying keymaps and pointer button mappings in X"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=4eafccf13653fd18ec3263631e5feb68"
PR = "r0"
PE = "1"
