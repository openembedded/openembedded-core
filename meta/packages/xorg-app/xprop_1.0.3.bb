require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " libxmu virtual/libx11"

