require xorg-app-common.inc

DESCRIPTION = "window information utility for X"
LIC_FILES_CHKSUM = "file://COPYING;md5=2f077ba838116bbe7cfaac34aff40328"
DEPENDS += "libxext libxmu"

PR = "r0"
PE = "0"
