require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxmu libxrender libxft libxext"
