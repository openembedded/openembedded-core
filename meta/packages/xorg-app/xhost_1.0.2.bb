require xorg-app-common.inc

DESCRIPTION = "Server access control program for X"
LICENSE = "MIT"
DEPENDS += "libxmu libxau"
PE = "1"
