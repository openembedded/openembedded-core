require xorg-app-common.inc

DESCRIPTION = "X Resize and Rotate extension command."
LICENSE= "BSD-X"

DEPENDS += " libxrandr libxrender virtual/libx11"

