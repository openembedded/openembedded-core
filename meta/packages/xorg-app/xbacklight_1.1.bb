require xorg-app-common.inc

DESCRIPTION = "X Backlight Utility"
DEPENDS += "libxrender libxrandr"
