require libusb_${PV}.bb
inherit native

