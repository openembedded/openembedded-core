LICENSE = "LGPL"
SECTION = "x11"
DEPENDS = "glib-2.0 gtk+ intltool eds-dbus"
RDEPENDS = "libedata-cal"

DESCRIPTION = "Dates is a calendar application."

include dates.inc
