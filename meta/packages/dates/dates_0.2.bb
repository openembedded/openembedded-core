LICENSE = "LGPL"
SECTION = "x11"
DEPENDS = "glib-2.0 gtk+ libglade eds-dbus"
DESCRIPTION = "Dates is a calendar application."

include dates.inc
