require git.inc
DEPENDS += "openssl curl zlib expat"
PR = "r0"
