require git.inc
inherit native
DEPENDS = "openssl-native curl-native"
