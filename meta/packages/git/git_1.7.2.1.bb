require git.inc

PR = "r2"
