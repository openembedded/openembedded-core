require git.inc
inherit native
DEPENDS = "openssl-native curl-native zlib-native expat-native"
PR = "r1"
