require util-linux.inc

PR = "r16"
