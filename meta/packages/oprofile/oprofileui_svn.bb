require oprofileui-svn.inc

DEPENDS = "glib-2.0 gtk+ libglade"

