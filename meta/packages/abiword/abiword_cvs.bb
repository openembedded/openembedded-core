require abiword.inc

SRCDATE="20070113"
PV="2.5.0+cvs${SRCDATE}"
PR = "r1"

SRC_URI = "${CVSURI}"

S = "${CVSSRC}"

