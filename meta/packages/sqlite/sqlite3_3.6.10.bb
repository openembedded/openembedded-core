require sqlite3.inc

PR = "r1"
