require sqlite3-native.inc
