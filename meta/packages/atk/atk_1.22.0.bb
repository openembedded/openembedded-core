require atk.inc

SRC_URI = "http://download.gnome.org/sources/atk/1.22/${PN}-${PV}.tar.bz2"



