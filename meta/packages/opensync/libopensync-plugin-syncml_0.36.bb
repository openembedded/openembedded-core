require libopensync-plugin_0.36.inc

DEPENDS += " libsyncml (>= 0.4.6)"
