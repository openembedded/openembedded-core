require libopensync-plugin_0.36.inc

DEPENDS += "openobex bluez-libs"
