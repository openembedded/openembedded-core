LICENSE = "LGPL"
DEPENDS = "libopensync gtk+"
SRC_URI = "http://www.o-hand.com/~chris/${PN}-${PV}.tar.gz"

inherit autotools pkgconfig

