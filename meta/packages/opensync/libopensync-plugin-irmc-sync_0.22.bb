require libopensync-plugin.inc
require libopensync-plugin_0.22.inc

DEPENDS += "openobex bluez-libs"
