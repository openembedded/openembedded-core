require libopensync-plugin_0.36.inc

DEPENDS += " eds-dbus"
