PLUGIN_ARCHIVE = "evolution2"

require libopensync-plugin.inc
require libopensync-plugin_0.22.inc

DEPENDS += " eds-dbus"
