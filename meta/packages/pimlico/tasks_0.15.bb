require tasks.inc

SRC_URI = "http://pimlico-project.org/sources/${PN}/${PN}-${PV}.tar.gz"

OWL_poky = "--with-owl"

PR = "r0"
