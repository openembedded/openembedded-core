require dates.inc

PR = "r1"

SRC_URI = "http://projects.o-hand.com/sources/dates/dates-${PV}.tar.gz"
