require dates.inc

SRC_URI = "http://pimlico-project.org/sources/dates/dates-${PV}.tar.gz \
	   file://dates-owl-window-menu.patch;patch=1 \
	  "
