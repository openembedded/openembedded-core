require dates.inc

SRC_URI = "http://projects.o-hand.com/sources/dates/dates-${PV}.tar.gz"
