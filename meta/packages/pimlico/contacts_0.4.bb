require contacts.inc

SRC_URI = "http://pimlico-project.org/sources/${PN}/${PN}-${PV}.tar.gz \
	   file://stock_contact.png \
	   file://stock_person.png"
