#
# Copyright (C) 2008 OpenedHand Ltd.
#
require poky-image-minimal.bb

IMAGE_INSTALL += "mtd-utils"
