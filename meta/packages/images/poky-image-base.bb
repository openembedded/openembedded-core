#
# Copyright (C) 2007 OpenedHand Ltd.
#

inherit poky-image
