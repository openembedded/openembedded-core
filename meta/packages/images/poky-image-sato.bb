#
# Copyright (C) 2007 OpenedHand Ltd.
#

IMAGE_FEATURES += "apps-core apps-pda"

inherit poky-image
