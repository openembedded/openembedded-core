require libxslt_${PV}.bb
inherit native

DEPENDS = "libxml2-native (>=2.6.27)"
