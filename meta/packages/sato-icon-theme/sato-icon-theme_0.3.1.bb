require sato-icon-theme.inc

DEPENDS += "icon-naming-utils-native"

SRC_URI = "http://pokylinux.org/releases/sato/${PN}-${PV}.tar.gz"
