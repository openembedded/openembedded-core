require sato-icon-theme.inc

SRC_URI = "http://pokylinux.org/releases/sato/${PN}-${PV}.tar.gz"
