include dbus.inc

PR = "r2"

inherit update-rc.d
