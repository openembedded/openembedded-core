require exmap-console.inc

PR = "r8"
