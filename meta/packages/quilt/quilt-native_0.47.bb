require quilt_${PV}.inc
require quilt-native.inc

PR = "r2"