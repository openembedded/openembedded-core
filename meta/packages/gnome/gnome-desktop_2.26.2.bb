require gnome-desktop.inc

SRC_URI += "file://no-desktop-docs.patch;patch=1;pnum=0"
