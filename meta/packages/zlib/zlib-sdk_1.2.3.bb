require zlib_${PV}.bb
require zlib-sdk.inc
