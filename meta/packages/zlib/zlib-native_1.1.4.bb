SECTION = "libs"
require zlib_${PV}.bb
inherit native
DEPENDS = ""
