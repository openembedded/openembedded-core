PV := "${PV}"

require automake-native.inc
