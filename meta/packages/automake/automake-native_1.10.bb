require automake-native.inc
