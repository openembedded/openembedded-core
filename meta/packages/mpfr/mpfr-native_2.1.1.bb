require mpfr_${PV}.bb
inherit native
DEPENDS = "gmp-native"

