require mpfr_${PV}.bb
inherit sdk
DEPENDS = "gmp-sdk"

