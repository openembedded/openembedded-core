require mpfr_${PV}.bb
inherit nativesdk
DEPENDS = "gmp-nativesdk"

