require libgcrypt.inc

PR = "r5"
