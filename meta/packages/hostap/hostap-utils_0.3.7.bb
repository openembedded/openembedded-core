require hostap-utils.inc

PR = "r3"
