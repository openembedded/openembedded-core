require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- keyboard input driver"

LIC_FILES_CHKSUM = "file://COPYING;md5=eae2c98cbb8c60401893ff9313ff3826"

PR = "r1"
