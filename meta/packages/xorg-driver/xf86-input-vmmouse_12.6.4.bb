require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- VMWare mouse input driver"

