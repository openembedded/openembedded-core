require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- evdev input driver"

LIC_FILES_CHKSUM = "file://COPYING;md5=ebf4ad82cd33b1432eacb1798a43c092"

PR = "r1"
