require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- mouse input driver"

LIC_FILES_CHKSUM = "file://COPYING;md5=43eb754a9f368985c40a2a5370fc364a"
