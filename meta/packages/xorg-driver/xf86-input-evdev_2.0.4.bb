require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- evdev input driver"

