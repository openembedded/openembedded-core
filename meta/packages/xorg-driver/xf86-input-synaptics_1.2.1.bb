require xf86-input-common.inc

DESCRIPTION = "X.Org X server -- keyboard input driver"

DEPENDS += "libxi"
