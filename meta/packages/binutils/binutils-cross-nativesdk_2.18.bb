require binutils_${PV}.bb
require binutils-cross-nativesdk.inc
PR = "r3"
