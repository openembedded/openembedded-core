require binutils_csl-arm-2005q3-2.bb
require binutils-cross.inc
S = "${WORKDIR}/binutils-2.17pre"
