FILESPATHPKG =. "binutils-${PV}:"
require binutils_${PV}.bb
require binutils-cross.inc

