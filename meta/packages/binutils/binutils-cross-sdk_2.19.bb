require binutils_${PV}.bb
require binutils-cross-sdk.inc
PR = "r0"
