require intltool.inc

SRC_URI_append = " file://intltool-nowarn-0.40.0.patch;patch=1"
