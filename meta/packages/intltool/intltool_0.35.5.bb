require intltool.inc

DEPENDS = "libxml-parser-perl-native"
#RDEPENDS = "libxml-parser-perl"

PR = "r0"

RRECOMMENDS = "perl-modules"

DEFAULT_PREFERENCE = "-1"
