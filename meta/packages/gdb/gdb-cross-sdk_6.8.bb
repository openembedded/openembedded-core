require gdb-cross.inc

DEPENDS = "ncurses-sdk expat-sdk"

inherit sdk

do_stage() {
	:
}
