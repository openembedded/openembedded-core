require gdb-cross.inc

inherit sdk

do_stage() {
	:
}
