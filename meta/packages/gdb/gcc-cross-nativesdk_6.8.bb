require gdb-cross.inc

DEPENDS = "ncurses-nativesdk expat-nativesdk"

inherit nativesdk

do_stage() {
	:
}
