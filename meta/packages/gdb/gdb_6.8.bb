require gdb.inc

PR = "r7"
