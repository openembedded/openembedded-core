require bash.inc
PR = "r1"

SRC_URI = "${GNU_MIRROR}/bash/bash-${PV}.tar.gz \
           file://001-005.patch;patch=1"
