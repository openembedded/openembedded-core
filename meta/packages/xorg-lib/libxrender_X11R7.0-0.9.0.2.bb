require xorg-lib-common.inc

DESCRIPTION = "X Render extension library."
LICENSE = "BSD-X"

DEPENDS += " virtual/libx11 renderproto"

XORG_PN = "libXrender"

