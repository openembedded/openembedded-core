require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto virtual/libx11 xextproto libxext evieext"

XORG_PN = "libXevie"

PE = "1"
