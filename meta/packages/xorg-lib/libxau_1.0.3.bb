require xorg-lib-common.inc
PE = "1"

DESCRIPTION = "A Sample Authorization Protocol for X"
PRIORITY = "optional"

DEPENDS += " xproto"
PROVIDES = "xau"

XORG_PN = "libXau"

