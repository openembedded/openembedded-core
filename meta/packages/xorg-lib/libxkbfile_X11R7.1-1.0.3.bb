require xorg-lib-common.inc

DESCRIPTION = "X11 keyboard library"
LICENSE= "GPL"
PRIORITY = "optional"

DEPENDS += " virtual/libx11 kbproto"

