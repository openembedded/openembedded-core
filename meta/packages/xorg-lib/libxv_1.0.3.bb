require xorg-lib-common.inc

DESCRIPTION = "X Video extension library."
LICENSE = "GPL"

DEPENDS += " virtual/libx11 libxext xextproto videoproto"

XORG_PN = "libXv"

