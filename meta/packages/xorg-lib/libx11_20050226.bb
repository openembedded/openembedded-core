SRCDATE = "20050226"

require libx11_cvs.bb

DEFAULT_PREFERENCE = "0"

