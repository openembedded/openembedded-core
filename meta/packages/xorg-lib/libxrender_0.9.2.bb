require xorg-lib-common.inc
PE = "1"

DESCRIPTION = "X Render extension library."
LICENSE = "BSD-X"

DEPENDS += " virtual/libx11 renderproto"

XORG_PN = "libXrender"

