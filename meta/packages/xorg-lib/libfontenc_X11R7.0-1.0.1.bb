require xorg-lib-common.inc

DESCRIPTION = "X fontenc library (used by libxfont)."
LICENSE = "BSD-X"
PRIORITY = "optional"

DEPENDS += " zlib xproto"

