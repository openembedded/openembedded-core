require xorg-lib-common.inc

DEPENDS += "xproto virtual/libx11"
