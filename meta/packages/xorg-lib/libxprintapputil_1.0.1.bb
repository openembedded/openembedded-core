require xorg-lib-common.inc

DESCRIPTION = "Xprint job utility client library"
DEPENDS += "libxp libxt libxprintutil"
PR = "r1"
PE = "1"

XORG_PN = "libXprintAppUtil"
