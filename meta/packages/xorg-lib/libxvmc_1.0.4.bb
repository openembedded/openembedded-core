require xorg-lib-common.inc
PE = "1"

DESCRIPTION = "X Video Motion Compensation extension library."

DEPENDS += " virtual/libx11 libxext libxv xextproto videoproto"

XORG_PN = "libXvMC"

