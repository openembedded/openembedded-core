require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxext xextproto windowswmproto"

XORG_PN = "libWindowsWM"

