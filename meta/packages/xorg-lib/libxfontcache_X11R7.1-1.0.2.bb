require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxext xextproto fontcacheproto"

XORG_PN = "libXfontcache"

