require xorg-lib-common.inc

DEPENDS += "libxext applewmproto"
PR = "r1"
PE = "1"

XORG_PN = "libAppleWM"
