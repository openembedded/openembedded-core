require xorg-lib-common.inc

#DESCRIPTION = " "

DEPENDS += " xproto fontsproto xtrans"

XORG_PN = "libFS"

PE = "1"
