require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxp libxt printproto libxau"

XORG_PN = "libXprintUtil"

