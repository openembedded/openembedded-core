require xorg-lib-common.inc

DESCRIPTION = "X cursor management library"
LICENSE= "BSD-X"
DEPENDS += "libxrender libxfixes"
PR = "r2"
PE = "1"

XORG_PN = "libXcursor"
