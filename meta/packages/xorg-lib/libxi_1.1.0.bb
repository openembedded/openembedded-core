require xorg-lib-common.inc
PE = "1"

DESCRIPTION = "X Input extension library."

DEPENDS += " xproto virtual/libx11 xextproto libxext inputproto"

XORG_PN = "libXi"

