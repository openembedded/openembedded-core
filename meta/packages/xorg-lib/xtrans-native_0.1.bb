SECTION = "x11/base"
require xtrans_${PV}.bb
inherit native
