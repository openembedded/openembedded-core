require xorg-lib-common.inc

DESCRIPTION = "Session management library"
PRIORITY = "optional"

DEPENDS += " libice xproto xtrans"

XORG_PN = "libSM"

