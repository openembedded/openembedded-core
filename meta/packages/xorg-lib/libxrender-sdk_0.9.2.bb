require libxrender_${PV}.bb

DEPENDS = "xproto-sdk renderproto-sdk util-macros-sdk libx11-sdk"

inherit sdk
