require xtrans_${PV}.bb

DEPENDS = "util-macros-sdk"

inherit sdk
