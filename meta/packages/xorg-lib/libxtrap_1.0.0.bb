require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxt trapproto libxext xextproto"

XORG_PN = "libXTrap"

PE = "1"
