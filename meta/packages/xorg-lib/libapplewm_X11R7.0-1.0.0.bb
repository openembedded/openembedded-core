require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxext xextproto applewmproto"

XORG_PN = "libAppleWM"

