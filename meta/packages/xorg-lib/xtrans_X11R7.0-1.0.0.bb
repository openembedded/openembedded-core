require xorg-lib-common.inc

DESCRIPTION = "network API translation layer to \
insulate X applications and libraries from OS \
network vageries."

#DEPENDS += " "

