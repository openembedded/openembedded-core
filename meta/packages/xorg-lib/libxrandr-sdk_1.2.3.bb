require libxrandr_${PV}.bb

DEPENDS = "randrproto-sdk util-macros-sdk libxext-sdk libxrender-sdk"

inherit sdk
