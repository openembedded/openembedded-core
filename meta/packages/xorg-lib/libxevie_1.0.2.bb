require xorg-lib-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xproto virtual/libx11 xextproto libxext evieext"

XORG_PN = "libXevie"

