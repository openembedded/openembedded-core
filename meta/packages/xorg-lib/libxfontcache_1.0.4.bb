require xorg-lib-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxext xextproto fontcacheproto"

XORG_PN = "libXfontcache"

