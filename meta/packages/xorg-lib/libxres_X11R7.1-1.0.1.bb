require xorg-lib-common.inc

DESCRIPTION = "X Resource usage library."

DEPENDS += " virtual/libx11 libxext xextproto resourceproto"

XORG_PN = "libXres"

