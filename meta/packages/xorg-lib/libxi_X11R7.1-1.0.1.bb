require xorg-lib-common.inc

DESCRIPTION = "X Input extension library."

DEPENDS += " xproto virtual/libx11 xextproto libxext inputproto"

XORG_PN = "libXi"

