SECTION = "x11/libs"
require libxdmcp_${PV}.bb
inherit native
DEPENDS = "xproto-native"
PROVIDES = ""
