require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto virtual/libx11 xextproto libxext xf86miscproto"
PROVIDES = "xxf86misc"

XORG_PN = "libXxf86misc"

