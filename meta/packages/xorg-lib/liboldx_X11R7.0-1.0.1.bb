require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11"

XORG_PN = "liboldX"

