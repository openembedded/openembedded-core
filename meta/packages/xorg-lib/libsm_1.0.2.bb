require xorg-lib-common.inc
PE = "1"

DESCRIPTION = "Session management library"
PRIORITY = "optional"

DEPENDS += " libice xproto xtrans"

XORG_PN = "libSM"

