require xorg-lib-common.inc
PE = "1"

DESCRIPTION = "X Resource usage library."

DEPENDS += " virtual/libx11 libxext xextproto resourceproto"

XORG_PN = "libXres"

