require libxext_${PV}.bb

DEPENDS = "xproto-sdk util-macros-sdk libx11-sdk libxau-sdk xextproto-sdk"
PROVIDES = ""

inherit sdk
