require xorg-lib-common.inc
PE = "1"

DESCRIPTION = "X fontenc library (used by libxfont)."
LICENSE = "BSD-X"
PRIORITY = "optional"

DEPENDS += " zlib xproto"

