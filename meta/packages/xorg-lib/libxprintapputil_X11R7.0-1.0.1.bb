require xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxp libxprintutil printproto libxau"

XORG_PN = "libXprintAppUtil"

