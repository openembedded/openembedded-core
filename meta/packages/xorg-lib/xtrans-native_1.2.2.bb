require xtrans_${PV}.bb

DEPENDS = "util-macros-native"

inherit native
