require xorg-lib-common.inc

DESCRIPTION = "XFIXES Extension"

DEPENDS += " xextproto xproto zlib"
PROVIDES = "lbxutil"
