require libxdmcp_${PV}.bb

DEPENDS = "xproto-sdk util-macros-sdk"
PROVIDES = ""

inherit sdk
