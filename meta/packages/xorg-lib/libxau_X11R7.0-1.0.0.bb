require xorg-lib-common.inc

DESCRIPTION = "A Sample Authorization Protocol for X"
PRIORITY = "optional"

DEPENDS += " xproto"
PROVIDES = "xau"

XORG_PN = "libXau"

