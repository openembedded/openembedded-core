PR = "r8"

require gcc-${PV}.inc
require gcc-cross.inc
require gcc-configure-cross.inc
require gcc-package-cross.inc
