require gcc-cross_csl-arm-2005q3.bb
require gcc-cross-intermediate.inc
