PR = "r7"

require gcc-${PV}.inc
require gcc-configure-target.inc
require gcc-native.inc
PROVIDES += "gcc3-native"
