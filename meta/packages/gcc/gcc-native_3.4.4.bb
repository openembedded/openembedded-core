require gcc_${PV}.bb
require gcc-native.inc
