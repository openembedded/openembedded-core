require mtd-utils_${PV}.bb
require mtd-utils-native.inc
