require glibc_${PV}.bb
require glibc-intermediate.inc

DEFAULT_PREFERENCE = "-1"

GLIBC_ADDONS = "nptl,libidn"


