require libdrm.inc

SRC_URI += "file://installtests.patch;patch=1"
PR = "r2"
