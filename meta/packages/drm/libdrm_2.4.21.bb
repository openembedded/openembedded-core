require libdrm.inc

SRC_URI += "file://installtests.patch"
PR = "r0"
