require curl_${PV}.bb
inherit nativesdk
DEPENDS = "zlib-nativesdk"

