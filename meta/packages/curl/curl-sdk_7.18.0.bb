require curl_${PV}.bb
inherit sdk
DEPENDS = "zlib-sdk"

