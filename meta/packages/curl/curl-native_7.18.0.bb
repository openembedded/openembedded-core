require curl_${PV}.bb
inherit native
DEPENDS = "zlib-native"

