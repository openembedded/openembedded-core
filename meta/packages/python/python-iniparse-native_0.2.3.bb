require python-iniparse_${PV}.bb
inherit native
DEPENDS = "python-native"
RDEPENDS = ""
NATIVE_INSTALL_WORKS = "1"

