require python-scons_${PV}.bb
inherit native
DEPENDS = "python-native"
RDEPENDS = ""
PR = "r0"

NATIVE_INSTALL_WORKS = "1"

