require python-urlgrabber_${PV}.bb
inherit native
DEPENDS = "python-native python-pycurl-native"
RDEPENDS = ""

NATIVE_INSTALL_WORKS = "1"

