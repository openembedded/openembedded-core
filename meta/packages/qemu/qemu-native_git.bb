require qemu_git.bb
require qemu-native.inc
