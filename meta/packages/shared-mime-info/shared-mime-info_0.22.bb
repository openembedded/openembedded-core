require shared-mime-info.inc

