require pango.inc

SRC_URI += "file://no-tests.patch;patch=1"
SRC_URI += "file://no-introspect.patch;patch=1"

