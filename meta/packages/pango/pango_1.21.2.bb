require pango.inc

SRC_URI += "file://no-tests.patch;patch=1"
