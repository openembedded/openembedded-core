require pango.inc

SRC_URI += "file://no-tests.patch;patch=1"
SRC_URI += "file://doublefix.patch;patch=1"

PR = "r1"
