require pkgconfig.inc
inherit nativesdk
DEPENDS = ""
