require pkgconfig.inc

PR = "r0"
