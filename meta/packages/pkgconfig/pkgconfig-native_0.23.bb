require pkgconfig.inc
inherit native
DEPENDS = ""
