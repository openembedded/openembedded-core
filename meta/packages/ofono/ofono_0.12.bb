require ofono.inc

PV	 = "0.12"

DEPENDS  = "dbus glib-2.0"

SRC_URI  = "http://www.kernel.org/pub/linux/network/ofono/${P}.tar.bz2 \
	    file://ofono"

