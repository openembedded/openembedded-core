DEPENDS = "gst-meta-base gst-plugins-good"
RDEPENDS = "gst-meta-base gst-plugin-debug gst-plugin-audiotestsrc \
            gst-plugin-videotestsrc"

ALLOW_EMPTY = "1"
