DEPENDS = "gst-meta-base gst-fluendo-mp3 gst-fluendo-mpegdemux"
RDEPENDS = "gst-meta-base gst-plugin-vorbis gst-plugin-ogg gst-fluendo-mp3 \
            gst-fluendo-mpegdemux"
PR = "r1"

ALLOW_EMPTY = "1"
