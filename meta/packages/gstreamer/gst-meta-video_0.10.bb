DEPENDS = "gst-meta-base gst-plugins-good gst-plugins-bad gst-ffmpeg"
RDEPENDS = "gst-meta-base gst-plugins-good gst-plugins-bad gst-plugin-avi \
	gst-plugin-matroska gst-plugin-ogg gst-ffmpeg"
RRECOMMENDS = "gst-meta-audio"

ALLOW_EMPTY = "1"
