SECTION = "console/utils"
require sed_${PV}.bb
inherit native
