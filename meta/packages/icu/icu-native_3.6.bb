require icu-3.6.inc

inherit native

PR = "r1"
