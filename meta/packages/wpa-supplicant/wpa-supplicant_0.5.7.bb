require wpa-supplicant-0.5.inc

SRC_URI += " file://gnutlsfix.patch;patch=1 "
