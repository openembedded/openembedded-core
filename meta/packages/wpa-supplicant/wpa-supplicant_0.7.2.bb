require wpa-supplicant-0.7.inc

PR = "r0"
