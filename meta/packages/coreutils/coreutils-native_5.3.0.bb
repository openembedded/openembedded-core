require coreutils_${PV}.bb
inherit native
