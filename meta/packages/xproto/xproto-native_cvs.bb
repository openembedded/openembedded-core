SECTION = "unknown"
include xproto_cvs.bb
inherit native
PROVIDES = ""
