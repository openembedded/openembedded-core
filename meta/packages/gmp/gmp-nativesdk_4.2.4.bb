require gmp_${PV}.bb
require gmp-nativesdk.inc
