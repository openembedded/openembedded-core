require gmp.inc

SRC_URI += "file://sh4-asmfix.patch;patch=1"