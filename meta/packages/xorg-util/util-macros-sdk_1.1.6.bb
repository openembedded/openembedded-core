require util-macros_${PV}.bb

inherit sdk
