require xorg-util-common.inc

DESCRIPTION = "imake utility"

DEPENDS += " perl xproto"

PE = "1"
