require xorg-util-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto"

PE = "1"
