require xorg-util-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

FILES_${PN} += " /usr/lib/X11/config"
