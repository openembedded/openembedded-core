require xorg-util-common.inc

DESCRIPTION = "create dependencies in makefiles using 'gcc -M'"
DEPENDS = "util-macros"
RDEPENDS = "gcc"

PR = "r2"
PE = "1"
