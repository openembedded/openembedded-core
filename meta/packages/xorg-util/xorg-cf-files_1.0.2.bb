require xorg-util-common.inc

#DESCRIPTION = ""

#DEPENDS += " "
PE = "1"

FILES_${PN} += " /usr/lib/X11/config"
