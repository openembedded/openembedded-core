require util-macros_${PV}.bb

inherit native
