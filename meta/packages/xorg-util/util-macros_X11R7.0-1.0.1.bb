require xorg-util-common.inc

DESCRIPTION = "X autotools macros"

#DEPENDS += " "

