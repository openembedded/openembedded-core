require xorg-util-common.inc

DESCRIPTION = "create dependencies in makefiles"
PR = "r1"
PE = "1"
