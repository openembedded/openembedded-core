require flex.inc
PR = "r0"

BBCLASSEXTEND = "native"
