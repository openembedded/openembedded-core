include libxcb.inc
PR = "r0"

DEPENDS += "libpthread-stubs"

PACKAGES =+ "libxcb-xinerama"
