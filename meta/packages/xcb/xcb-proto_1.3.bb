include xcb-proto.inc
PR = "r1"

DEFAULT_PREFERENCE = "-1"