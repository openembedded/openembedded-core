include libxcb.inc
PR = "r1"

DEPENDS += "libpthread-stubs"

PACKAGES =+ "libxcb-xinerama"
