require hal-info.inc
