require libcap.inc

PR = "r0"
