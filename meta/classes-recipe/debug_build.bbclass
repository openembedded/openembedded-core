#
# Copyright OpenEmbedded Contributors
#
# SPDX-License-Identifier: MIT
#

# Allow other layers to add their own debug build configurations
include_all conf/distro/include/debug_build.inc
