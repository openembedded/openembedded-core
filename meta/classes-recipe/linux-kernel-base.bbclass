#
# Copyright OpenEmbedded Contributors
#
# SPDX-License-Identifier: MIT
#

export KBUILD_BUILD_VERSION = "1"
export KBUILD_BUILD_USER ?= "oe-user"
export KBUILD_BUILD_HOST ?= "oe-host"

