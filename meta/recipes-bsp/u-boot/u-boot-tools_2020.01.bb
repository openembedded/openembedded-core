require u-boot-common.inc
require u-boot-tools.inc

SRC_URI += "file://remove-redundant-yyloc-global.patch"
