require u-boot-common.inc
require u-boot-tools.inc

SRC_URI += "file://CVE-2026-46728.patch"
