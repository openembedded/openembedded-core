require acpid.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=8ca43cbc842c2336e835926c2166c28b \
                    file://acpid.h;endline=24;md5=324a9cf225ae69ddaad1bf9d942115b5"

SRC_URI[md5sum] = "6dd58a35cac51bd9503d769f5d13d74d"
SRC_URI[sha256sum] = "58503b27975c466e627eb741c5453dd662f97edef1a3d0aac822fd03a84203ff"
