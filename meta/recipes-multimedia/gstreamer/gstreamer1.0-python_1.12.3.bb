require gstreamer1.0-python.inc

SRC_URI = "http://gstreamer.freedesktop.org/src/${PNREAL}/${PNREAL}-${PV}.tar.xz"
SRC_URI[md5sum] = "622125816c52a51205660d210f8e7b8b"
SRC_URI[sha256sum] = "c3f529dec1294633132690806703b80bad5752eff482eaf81f209c2aba012ba7"

LIC_FILES_CHKSUM = "file://COPYING;md5=c34deae4e395ca07e725ab0076a5f740"
