include gstreamer1.0-rtsp-server.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"

SRC_URI[md5sum] = "0a5966df7f3d74cccfcededdcacd8212"
SRC_URI[sha256sum] = "6fa8d9ce5b6f6f3309ab9eae14739af4f5666e259cdc64d0667d284ab17eb12e"
