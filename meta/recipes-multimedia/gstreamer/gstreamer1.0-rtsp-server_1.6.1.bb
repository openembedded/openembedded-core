include gstreamer1.0-rtsp-server.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"

SRC_URI[md5sum] = "fbb67bb9375ae483fcffe6390bcfbefb"
SRC_URI[sha256sum] = "4308110981c768dcbcc92ee29c49a4f6dbd2560bb82e33b10d197e10c74bb72c"
