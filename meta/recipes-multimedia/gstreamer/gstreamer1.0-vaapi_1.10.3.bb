require gstreamer1.0-vaapi.inc
SRC_URI[md5sum] = "ddd78e8f24b4736ad856c0de88531277"
SRC_URI[sha256sum] = "cea827066a152a6afa1d0c43544dfbda285238156d4c3b77f9d4037bbe79361e"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
