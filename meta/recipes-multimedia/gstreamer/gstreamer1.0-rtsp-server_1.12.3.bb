require gstreamer1.0-rtsp-server.inc

SRC_URI[md5sum] = "83ae8adda3b9c6164cd2fba1efdde87e"
SRC_URI[sha256sum] = "67255971bb16029a01de66b9f9687f20d8dbf3d3bd75feb48605d0723a7c74ec"

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"
