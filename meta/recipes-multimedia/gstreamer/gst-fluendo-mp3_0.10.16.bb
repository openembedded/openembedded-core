require gst-fluendo.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=98326cbb1723a5a97e9b1db62e9faa05"
LICENSE_FLAGS = "commercial"

acpaths = "-I ${S}/common/m4 -I ${S}/m4"

PR = "r0"

DESCRIPTION = "Fluendo closed-format mp3 GStreamer plug-in"

SRC_URI[md5sum] = "33df57590e3f21f945fe7bace6146fa0"
SRC_URI[sha256sum] = "12dbd307b25fed502a52666a9c956230da09ee140a18d987452492393340f442"
