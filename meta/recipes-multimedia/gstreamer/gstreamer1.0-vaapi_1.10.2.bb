require gstreamer1.0-vaapi.inc
SRC_URI[md5sum] = "cd8771280c8c00929cf7251c38a509dc"
SRC_URI[sha256sum] = "9e31d2b85b2f30caa6b0cc1c6be10b96e1376668f13faa6a0f577d3693547fa9"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
