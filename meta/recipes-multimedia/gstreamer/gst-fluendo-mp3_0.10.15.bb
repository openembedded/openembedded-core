require gst-fluendo.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=98326cbb1723a5a97e9b1db62e9faa05"

acpaths = "-I ${S}/common/m4 -I ${S}/m4"

PR = "r0"

DESCRIPTION = "Fluendo closed-format mp3 GStreamer plug-in"

SRC_URI[md5sum] = "dac7a9fa988650ec1be6c4c743a86cd4"
SRC_URI[sha256sum] = "b444e6f3f87f5b819c1327ff3ed1afe9c09c195ba79ecf7e7409b375fa81cb06"
