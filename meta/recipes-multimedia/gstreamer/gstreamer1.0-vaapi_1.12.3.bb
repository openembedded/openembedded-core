require gstreamer1.0-vaapi.inc
SRC_URI[md5sum] = "aa9ea10623f34680a39b32e243add26d"
SRC_URI[sha256sum] = "f4cdafd8fd9606a490917c8b67336e835df1219580d55421c70480fd0913744d"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
