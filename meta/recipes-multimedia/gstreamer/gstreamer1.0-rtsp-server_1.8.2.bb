include gstreamer1.0-rtsp-server.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"

SRC_URI[md5sum] = "193ae75a676f39294f64b162bbe2369d"
SRC_URI[sha256sum] = "7d414cd4302ae253821dcb22d483fadc9d21cf96b5fd4c0a33fd41960f8e0459"
