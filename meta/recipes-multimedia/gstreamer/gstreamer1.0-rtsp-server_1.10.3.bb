require gstreamer1.0-rtsp-server.inc

SRC_URI[md5sum] = "2c6bdf872443a8b5bb567462c267bdb1"
SRC_URI[sha256sum] = "baf9f7d229711cb3d823a447a930132f809b3321eab3535491bb01c8a21566fe"

LIC_FILES_CHKSUM = "file://COPYING;md5=6762ed442b3822387a51c92d928ead0d"
