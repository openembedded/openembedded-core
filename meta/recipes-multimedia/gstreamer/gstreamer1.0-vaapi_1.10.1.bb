require gstreamer1.0-vaapi.inc

SRC_URI[md5sum] = "514757933ff719a6b8206091f70e0221"
SRC_URI[sha256sum] = "99aecaa609f37d65e12518b1e77cc70e3cc5dde0c7dfc8e83f508d7e64e1da34"

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"
