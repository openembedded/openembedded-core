require ${BPN}.inc

SRC_URI += " file://0001-vapigen.m4-use-PKG_CONFIG_SYSROOT_DIR.patch"

SRC_URI[sha256sum] = "6051270a2fc30de023c88562566f2f6043e67beb4da4b799c14cdf12048eb40c"
