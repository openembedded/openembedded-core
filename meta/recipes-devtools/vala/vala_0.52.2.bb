require ${BPN}.inc

SRC_URI += " file://0001-vapigen.m4-use-PKG_CONFIG_SYSROOT_DIR.patch"

SRC_URI[sha256sum] = "3a3c460803ba661e513be3d0984b583e05473f602c75fa98e91755503714a97b"
