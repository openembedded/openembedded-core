require python-scons_${PV}.bb
inherit native
DEPENDS = "python-native"
RDEPENDS = ""
PR = "r0"

