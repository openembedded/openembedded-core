inherit setuptools3
require python-pbr.inc

SRC_URI[md5sum] = "62565acc6bf3e7e10b082463421f8b46"
SRC_URI[sha256sum] = "42df03e7797b796625b1029c0400279c7c34fd7df24a7d7818a1abb5b38710dd"
