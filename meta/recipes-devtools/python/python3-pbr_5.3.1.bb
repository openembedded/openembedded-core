inherit setuptools3
require python-pbr.inc

SRC_URI[md5sum] = "bdaec663a75d10e9e0f2224afa3a1318"
SRC_URI[sha256sum] = "9181e2a34d80f07a359ff1d0504fad3a47e00e1cf2c475b0aa7dcb030af54c40"
