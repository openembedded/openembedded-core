inherit distutils3
require python-gitdb.inc
