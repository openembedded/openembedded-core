require python-iniparse_${PV}.bb
inherit native
DEPENDS = "python-native"
RDEPENDS = ""
PR = "r0"

