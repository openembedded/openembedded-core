inherit setuptools3
require python-pbr.inc

SRC_URI[sha256sum] = "4651ca1445e80f2781827305de3d76b3ce53195f2227762684eb08f17bc473b7"
