inherit setuptools3
require python-pbr.inc

SRC_URI[md5sum] = "fcf120102d3e4859d41425638122058c"
SRC_URI[sha256sum] = "36ebd78196e8c9588c972f5571230a059ff83783fabbbbedecc07be263ccd7e6"
