inherit pypi setuptools3
require python-pyasn1.inc

CVE_PRODUCT = "pyasn1:pyasn1"
