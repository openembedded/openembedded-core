inherit setuptools3
require python-pbr.inc
SRC_URI[md5sum] = "dbc94417a8ff0432d6244501a7f1bd49"
SRC_URI[sha256sum] = "f59d71442f9ece3dffc17bc36575768e1ee9967756e6b6535f0ee1f0054c3d68"

