require python-pycryptodome.inc
inherit setuptools3

SRC_URI[sha256sum] = "ceea92a4b8ba6c50d8d70f2efbb4ea14b002dac4160ce4dda33f1b7442f8158a"

