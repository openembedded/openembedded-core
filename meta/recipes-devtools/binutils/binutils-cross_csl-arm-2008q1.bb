require binutils_csl-arm-2008q1.bb
require binutils-cross.inc
PR = "r1"
