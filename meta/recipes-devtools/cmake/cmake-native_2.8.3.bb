CMAKE_MAJOR_VERSION="2.8"
require cmake.inc
inherit native
PR = "r1"

SRC_URI[md5sum] = "a76a44b93acf5e3badda9de111385921"
SRC_URI[sha256sum] = "689ed02786b5cefa5515c7716784ee82a82e8ece6be5a3d629ac3cc0c05fc288"
