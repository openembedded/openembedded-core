require cmake.inc
inherit native

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ba74b22c788a0c8547976b880cd02b17"
SRC_URI[sha256sum] = "2b59897864d6220ff20aa8eac64cac8994e004898a1c0f899c8cb4d7b7570b46"

