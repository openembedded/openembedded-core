require cmake.inc
inherit native

SRC_URI[md5sum] = "be6008f2299613d23fe82ab53ef7472e"
SRC_URI[sha256sum] = "20d0d3661797fa82c19e7a75c7315c640e001cb3238331ca170bb0fae27feee5"
