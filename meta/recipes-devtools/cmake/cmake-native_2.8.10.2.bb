require cmake.inc
inherit native

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "097278785da7182ec0aea8769d06860c"
SRC_URI[sha256sum] = "ce524fb39da06ee6d47534bbcec6e0b50422e18b62abc4781a4ba72ea2910eb1"
