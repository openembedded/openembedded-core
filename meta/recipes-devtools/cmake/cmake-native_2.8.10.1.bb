require cmake.inc
inherit native

PR = "${INC_PR}.0"
