require cmake.inc
inherit native

SRC_URI[md5sum] = "df5324a3b203373a9e0a04b924281a43"
SRC_URI[sha256sum] = "b7dbb86824051319b8e082d2f892ebe6d5914b4dac9b9ef1aeac5e7ed054b0bf"
