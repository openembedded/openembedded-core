require gdb-common.inc
require gdb-cross-canadian.inc
require gdb-7.6.inc

GDBPROPREFIX = "--program-prefix='${TARGET_PREFIX}'"
