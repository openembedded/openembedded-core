require gdb-common.inc
require gdb-cross-canadian.inc

PR = "r1"

GDBPROPREFIX = "--program-prefix='${TARGET_PREFIX}'"
EXPAT = "--with-expat"
