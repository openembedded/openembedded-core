require gdb-cross.inc
require gdb-7.6.inc

SRC_URI += "file://sim-install-6.6.patch"
