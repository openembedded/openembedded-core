require quilt-${PV}.inc
require quilt-native.inc

PR = "r0"
