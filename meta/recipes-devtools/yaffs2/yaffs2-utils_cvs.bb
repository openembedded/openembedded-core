require yaffs2-utils.inc
PR = "r1"

