require ccache.inc

PR = "r0"
LICENSE = "GPLv3+"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=80e92ec45d4fca91f127864fb9e5d932"

SRC_URI[md5sum] = "bf49574730fabd666fc7ec3f8b203f41"
SRC_URI[sha256sum] = "278f4d1d38fc530221c7ce73606f34bc3a5df7e269930e4fb1d9ac44f4345d11"
