require ccache.inc

PR = "r0"
LICENSE = "GPLv3+"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=80e92ec45d4fca91f127864fb9e5d932"

SRC_URI[md5sum] = "ffa001305f31f44a3834be7c6c5102c5"
SRC_URI[sha256sum] = "9c4134a88d2566ba41a070a6cedc53fa92e1008f40c116c61e73dde16453d63e"
