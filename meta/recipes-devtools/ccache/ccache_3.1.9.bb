require ccache.inc

LICENSE = "GPLv3+"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=80e92ec45d4fca91f127864fb9e5d932"

SRC_URI[md5sum] = "522a6016bda56892653612bbdefff3e0"
SRC_URI[sha256sum] = "4981fdf3ad851de400d94083a0d03f115ce9ce8062c3fd7a291630294b0006c4"
