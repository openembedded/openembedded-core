require update-alternatives-dpkg.inc

PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

SRC_URI[md5sum] = "0266b06ef9da8278cea008d21e17e5f6"
SRC_URI[sha256sum] = "69669720020e67629d70aa5325e3c20c05cae7a9fc2d8abd442672c7b29e31d3"
