PR = "r0"

require make.inc
