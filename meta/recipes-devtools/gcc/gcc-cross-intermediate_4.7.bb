require recipes-devtools/gcc/gcc-cross_${PV}.bb
require gcc-cross-intermediate.inc

