require recipes-devtools/gcc/gcc-${PV}.inc
require gcc-configure-runtime.inc
require gcc-package-runtime.inc

