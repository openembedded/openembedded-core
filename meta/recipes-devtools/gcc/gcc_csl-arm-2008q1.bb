require gcc-${PV}.inc
require gcc-configure-target.inc
require gcc-package-target.inc
