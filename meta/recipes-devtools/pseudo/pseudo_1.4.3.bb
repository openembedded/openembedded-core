require pseudo.inc

PR = "r0"

SRC_URI = "http://www.yoctoproject.org/downloads/${BPN}/${BPN}-${PV}.tar.bz2"

SRC_URI[md5sum] = "ac943153aa78e210e2d0db7c85845db3"
SRC_URI[sha256sum] = "0ca12a319c0ee87d1c8b2a4310c36a6d68d8d4b8c9c7dba00bace1773baf18e8"
