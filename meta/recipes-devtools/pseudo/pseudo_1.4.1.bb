require pseudo.inc

PR = "r13"

SRC_URI = "http://www.yoctoproject.org/downloads/${BPN}/${BPN}-${PV}.tar.bz2"

SRC_URI[md5sum] = "b49bb87c7e1de33f37fea479ddb99dca"
SRC_URI[sha256sum] = "ae4bfba2bd1e3954ea8f83bf06571ee4958bf7623e4fa897056281dddfe6446d"
