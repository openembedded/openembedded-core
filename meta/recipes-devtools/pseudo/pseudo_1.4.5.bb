require pseudo.inc

PR = "r0"

SRC_URI = "http://www.yoctoproject.org/downloads/${BPN}/${BPN}-${PV}.tar.bz2"

SRC_URI[md5sum] = "1b8677f7730bd4c51daab7727c35123e"
SRC_URI[sha256sum] = "e36360e4899467ac842fece894177cb50207671a90e0567ffc74c144fa377f51"
