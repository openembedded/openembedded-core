require gnutls.inc

SRC_URI += "file://correct_rpl_gettimeofday_signature.patch \
           "

SRC_URI[md5sum] = "300e5f413054e2f4719c1c3b5179a611"
SRC_URI[sha256sum] = "e83676218ba80c4d577d7027b5b087692280347a9b06f90a452403ba70faa604"
