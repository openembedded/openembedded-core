require gnutls.inc

SRC_URI += "file://correct_rpl_gettimeofday_signature.patch \
           "

SRC_URI[md5sum] = "ec3b06f80e312137386c5d322183ca5a"
SRC_URI[sha256sum] = "30bdc7b34b220258f714602cdf0afa1abf0883bf926f35f400c88b1c72ca77b9"
