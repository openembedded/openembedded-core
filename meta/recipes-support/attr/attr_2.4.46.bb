require attr.inc

PR = "r4"

SRC_URI[md5sum] = "db557c17fdfa4f785333ecda08654010"
SRC_URI[sha256sum] = "dcd69bdca7ff166bc45141eddbcf21967999a6b66b0544be12a1cc2fd6340e1f"
