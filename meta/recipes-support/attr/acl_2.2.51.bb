require acl.inc

PR = "r3"

SRC_URI[md5sum] = "3fc0ce99dc5253bdcce4c9cd437bc267"
SRC_URI[sha256sum] = "06854521cf5d396801af7e54b9636680edf8064355e51c07657ec7442a185225"
