require hal-info.inc

PR = "r1"

SRC_URI[md5sum] = "34375489a02a00b250fdc0b280be11b8"
SRC_URI[sha256sum] = "3b5a90eaea4359977d36c808a19b3f08835345a258c68b9c6c080ad5ef875224"
