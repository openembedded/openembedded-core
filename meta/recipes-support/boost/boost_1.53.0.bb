include boost.inc

LIC_FILES_CHKSUM = "file://LICENSE_1_0.txt;md5=e4224ccaecb14d942c71d31bef20d78c"

SRC_URI += "file://arm-intrinsics.patch \
           "

SRC_URI[md5sum] = "a00d22605d5dbcfb4c9936a9b35bc4c2"
SRC_URI[sha256sum] = "f88a041b01882b0c9c5c05b39603ec8383fb881f772f6f9e6e6fd0e0cddb9196"
