include boost-jam-native.inc

PR = "${INC_PR}.0"

SRC_URI = "${SOURCEFORGE_MIRROR}/boost/boost-jam-${PV}.tgz"

SRC_URI[md5sum] = "f790e022d658db38db5cc4aeeccad3f1"
SRC_URI[sha256sum] = "85dbb72c29837ba89cb5408782c82459b34fdecaedea8b54ce1cb3cb9990121a"
