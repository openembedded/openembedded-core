include boost.inc

LIC_FILES_CHKSUM = "file://LICENSE_1_0.txt;md5=e4224ccaecb14d942c71d31bef20d78c"

SRC_URI += "file://arm-intrinsics.patch \
           "
SRC_URI[md5sum] = "3a855e0f919107e0ca4de4d84ad3f750"
SRC_URI[sha256sum] = "222b6afd7723f396f5682c20130314a10196d3999feab5ba920d2a6bf53bac92"

