require libgcrypt.inc

SRC_URI[md5sum] = "d19adc062edff0ebc7e887212733ef1f"
SRC_URI[sha256sum] = "936921644b9c81e2395e18a554a9a5f9252aae3976f8afc3e4229ee9d785e627"
