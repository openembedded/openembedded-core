require libgcrypt.inc

SRC_URI[md5sum] = "9963b67d84978727f5795e7ff92385de"
SRC_URI[sha256sum] = "d7f5cb694286b24d91836c728dfcac9e8eead80a02c5e2ac78d8b84983154455"
