require libgcrypt.inc

SRC_URI[md5sum] = "e695bc5c2c05d43779bae800efbd5cd8"
SRC_URI[sha256sum] = "8aac9b45080ab431cbb21f5be1a2cfc9d67ab2b41747a09794c48c4de8c62d7d"
