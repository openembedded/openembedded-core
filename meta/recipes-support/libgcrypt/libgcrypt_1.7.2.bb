require libgcrypt.inc

SRC_URI[md5sum] = "b28de2eaf8fc0c916c76ab67be5a3790"
SRC_URI[sha256sum] = "70c8e439420823505b39addbf51c469ef0df5a1372fa1d7d33ec9261079d08e2"
