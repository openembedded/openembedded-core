require libgcrypt.inc

SRC_URI[md5sum] = "36ace8f8dc4b1a82793ae759bbfc806f"
SRC_URI[sha256sum] = "0e72e91290d553c303095a50ea660279d8f11b76c6c86e826f470442fcdf1edd"
