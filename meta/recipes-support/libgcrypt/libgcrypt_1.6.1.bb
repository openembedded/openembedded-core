require libgcrypt.inc

SRC_URI += "file://libgcrypt-1.6.1-make-arm-asm-fPIC-friendly.patch"

SRC_URI[md5sum] = "d155aa1b06fa879175922ba28f6a6509"
SRC_URI[sha256sum] = "7c1007197bef49c3b8740cf6af8b4eb4eb74c7a69796ebcf555d928c287255de"
