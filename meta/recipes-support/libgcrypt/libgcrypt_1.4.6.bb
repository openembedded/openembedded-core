require libgcrypt.inc

PR = "r1"

SRC_URI[md5sum] = "bfd45922eefb8a24d598af77366220d4"
SRC_URI[sha256sum] = "996d2874643318c9df835777034a8b7a923d3cd0bee593bab1780305f9de872d"
