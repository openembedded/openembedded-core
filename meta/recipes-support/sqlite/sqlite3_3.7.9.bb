require sqlite3.inc

PR = "r0"

LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3070900.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3070900"

SRC_URI[md5sum] = "dce303524736fe89a76b8ed29d566352"
SRC_URI[sha256sum] = "7be6cdb375505e5d9a4aee88b2ddb6ea0d9d29c9545114ff77b345e1fa812439"
