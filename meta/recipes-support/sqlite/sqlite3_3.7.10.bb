require sqlite3.inc

PR = "r2"

LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3071000.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3071000"

SRC_URI[md5sum] = "9ed2ca93577b58cfa0d01f64b9312ab9"
SRC_URI[sha256sum] = "9c1775057af5cc8b6cc64808b9553d77beccf3757e16ecee3bc878404d9c43e3"
