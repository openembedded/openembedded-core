require sqlite3.inc

LICENSE = "PD"
LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

SRC_URI = "http://www.sqlite.org/2016/sqlite-autoconf-${SQLITE_PV}.tar.gz"

SRC_URI[md5sum] = "4e83f39fa2ffb610ac5ecd36865da6a2"
SRC_URI[sha256sum] = "e2797026b3310c9d08bd472f6d430058c6dd139ff9d4e30289884ccd9744086b"
