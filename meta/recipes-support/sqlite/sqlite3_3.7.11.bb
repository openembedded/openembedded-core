require sqlite3.inc

LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

PR = "r0"

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3071100.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3071100"

SRC_URI[md5sum] = "0552d71bda98ebdcaea305cd6058221b"
SRC_URI[sha256sum] = "2badc75dc536249bcd68c44d2a655724285d054303251eaff9d355194cb3476b"
