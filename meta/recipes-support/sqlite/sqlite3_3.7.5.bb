require sqlite3.inc

LIC_FILES_CHKSUM = "file://sqlite3.c;endline=19;md5=c1b8048b783961c3ba387c43fd955dc6"

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3070500.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3070500"
PR = "r0"

SRC_URI[md5sum] = "a9604a82613ade2e7f4c303f233e477f"                                                 
SRC_URI[sha256sum] = "cb5b86926ec9f65882b2dddd244f2d620337d911ec73411863f77e48cf6a2f94"              
