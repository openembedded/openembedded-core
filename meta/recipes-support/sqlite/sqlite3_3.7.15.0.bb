require sqlite3.inc

LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

PR = "r0"

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3071500.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3071500"

SRC_URI[md5sum] = "0d2a2d27b56ac73d49db76dcb6b4619c"
SRC_URI[sha256sum] = "fee53abf5ce8f44ef37cdc734551d82295fc933f522911d371d3421ccd305d48"
