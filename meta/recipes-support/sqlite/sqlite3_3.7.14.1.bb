require sqlite3.inc

LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

PR = "r0"

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3071401.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3071401"

SRC_URI[md5sum] = "4cf3fd434bbb6e50777019ff3507bfa5"
SRC_URI[sha256sum] = "d46d302a63b23d9c3b80e519be12cb7d6a8d3da57bd9c119341a0aa8b3b28692"
