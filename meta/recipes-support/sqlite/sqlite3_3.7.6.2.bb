require sqlite3.inc

LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3070602.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3070602"
PR = "r0"

SRC_URI[md5sum] = "f16c08617968b4087b3d591fd575f59f"
SRC_URI[sha256sum] = "53aa66f30d8ff87230d4173b7979814432b8084da77fba05992223f76593fc81"
