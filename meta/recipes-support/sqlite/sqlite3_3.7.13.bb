require sqlite3.inc

LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

PR = "r1"

SRC_URI = "http://www.sqlite.org/sqlite-autoconf-3071300.tar.gz"
S = "${WORKDIR}/sqlite-autoconf-3071300"

SRC_URI[md5sum] = "c97df403e8a3d5b67bb408fcd6aabd8e"
SRC_URI[sha256sum] = "ac566819f82ec4cc2ff6c5cc90987ca38e589efbd79ff263838bbc62356ab119"
