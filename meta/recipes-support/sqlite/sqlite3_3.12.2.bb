require sqlite3.inc

LICENSE = "PD"
LIC_FILES_CHKSUM = "file://sqlite3.h;endline=11;md5=65f0a57ca6928710b418c094b3570bb0"

SRC_URI = "http://www.sqlite.org/2016/sqlite-autoconf-${SQLITE_PV}.tar.gz"

SRC_URI[md5sum] = "c552a133aca1ce1d647163d9e43bbcb1"
SRC_URI[sha256sum] = "fd00770c9afd39db555c78400e52f55e8bd6568c78be23561abb472a22d09abb"
