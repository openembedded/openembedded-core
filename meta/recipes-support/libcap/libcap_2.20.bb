require libcap.inc

PR = "r1"

SRC_URI[md5sum] = "10e47ed32ca2214eb0e58780282d27b4"
SRC_URI[sha256sum] = "20e7c1ea4d3d5c410efb3a6ff138dc417912fae316d883460dcd58d9803a9220"
