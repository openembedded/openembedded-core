require libcap.inc

PR = "r1"

SRC_URI[md5sum] = "eb1ff04d39bfa2342b8e78b0fd60dc2d"
SRC_URI[sha256sum] = "ed1693e344054a398e68a7cc840892e3d1a880562743bdf28fd918649aa5a4ce"
