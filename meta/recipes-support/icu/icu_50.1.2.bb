require icu.inc

LIC_FILES_CHKSUM = "file://../license.html;md5=4ee45701e87d34303281978e3b78ecda"

PR = "r0"

BASE_SRC_URI = "http://download.icu-project.org/files/icu4c/${PV}/icu4c-50_1_2-src.tgz"
SRC_URI = "${BASE_SRC_URI}"

SRC_URI[md5sum] = "beb98aa972219c9fcd9c8a71314943c9"
SRC_URI[sha256sum] = "cb68067dcc60d682f8e037bf0961bdd5169cb4652ef8aa136e893780047dafd3"
