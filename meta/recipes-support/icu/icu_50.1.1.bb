require icu.inc

LIC_FILES_CHKSUM = "file://../license.html;md5=4ee45701e87d34303281978e3b78ecda"

PR = "r0"

BASE_SRC_URI = "http://download.icu-project.org/files/icu4c/${PV}/icu4c-50_1_1-src.tgz"
SRC_URI = "${BASE_SRC_URI}"

SRC_URI[md5sum] = "c721c2e0c8f86975ccea620d09aedc81"
SRC_URI[sha256sum] = "a6f426e3c04749c74bcb9d2ce229f905de88deda2353db2249f2e96fe604df8f"
