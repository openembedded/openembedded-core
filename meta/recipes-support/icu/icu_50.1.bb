require icu.inc

LIC_FILES_CHKSUM = "file://../license.html;md5=4ee45701e87d34303281978e3b78ecda"

PR = "r1"

BASE_SRC_URI = "http://download.icu-project.org/files/icu4c/50.1/icu4c-50_1-src.tgz"
SRC_URI = "${BASE_SRC_URI}"

SRC_URI[md5sum] = "cf7bf9e56aa6c2057a8b6f464046483e"
SRC_URI[sha256sum] = "68592b3c07d9b86100f41d0172eb1a81f3ffb2a8fef1104d7395099079ba7350"