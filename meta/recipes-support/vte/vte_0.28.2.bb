require vte.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

PR = "r6"

SRC_URI += "file://obsolete_automake_macros.patch"

SRC_URI[archive.md5sum] = "f07a4bf943194f94b7f142db8f7f36dc"
SRC_URI[archive.sha256sum] = "8d04e202b617373dfb47689e5e628febe2c58840b34cccc4af4feb88c48df903"
