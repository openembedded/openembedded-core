require nss.inc

SRC_URI += "\
    http://ftp.mozilla.org/pub/mozilla.org/security/nss/releases/NSS_3_17_3_RTM/src/${BP}.tar.gz \
"
SRC_URI[md5sum] = "fba7489e1b26f2a0bfe5527430fd61e1"
SRC_URI[sha256sum] = "f4d5e9035a2f84f25f35c283de3b0ff60d72e918748de25eaf017ed201fa21d5"
