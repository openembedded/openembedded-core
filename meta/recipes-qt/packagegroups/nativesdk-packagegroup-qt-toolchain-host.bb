require nativesdk-packagegroup-qt-toolchain-host.inc

DESCRIPTION = "Host packages for Qt SDK"
