require qt4-native.inc

PR = "${INC_PR}.0"

TOBUILD := "src/tools/bootstrap ${TOBUILD}"

SRC_URI[md5sum] = "89c5ecba180cae74c66260ac732dc5cb"
SRC_URI[sha256sum] = "33b0e38ba4c54a0cf8a4be8ca5a4584f1c2e0adfecb57b21d9d1d267b0093270"
