require nativesdk-qt4-tools.inc

SRC_URI += "file://0009-qmake-fix-source-file-references-in-qmake.pri.patch"

SRC_URI[md5sum] = "2edbe4d6c2eff33ef91732602f3518eb"
SRC_URI[sha256sum] = "8b14dd91b52862e09b8e6a963507b74bc2580787d171feda197badfa7034032c"
