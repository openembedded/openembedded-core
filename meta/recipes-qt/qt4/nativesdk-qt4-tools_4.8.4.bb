require nativesdk-qt4-tools.inc

PR = "${INC_PR}.0"

SRC_URI += "file://0009-qmake-fix-source-file-references-in-qmake.pri.patch"

SRC_URI[md5sum] = "89c5ecba180cae74c66260ac732dc5cb"
SRC_URI[sha256sum] = "33b0e38ba4c54a0cf8a4be8ca5a4584f1c2e0adfecb57b21d9d1d267b0093270"
