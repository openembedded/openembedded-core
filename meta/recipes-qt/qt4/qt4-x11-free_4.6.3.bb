require qt4-x11-free.inc
require qt-4.6.3.inc

PR = "r0"

QT_CONFIG_FLAGS += " -xrandr "
