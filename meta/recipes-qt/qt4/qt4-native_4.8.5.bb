require qt4-native.inc

TOBUILD := "src/tools/bootstrap ${TOBUILD}"

SRC_URI[md5sum] = "1864987bdbb2f58f8ae8b350dfdbe133"
SRC_URI[sha256sum] = "eb728f8268831dc4373be6403b7dd5d5dde03c169ad6882f9a8cb560df6aa138"
