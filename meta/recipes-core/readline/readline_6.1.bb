require readline.inc

PR = "r0"

SRC_URI[md5sum] = "fc2f7e714fe792db1ce6ddc4c9fb4ef3"
SRC_URI[sha256sum] = "f0caf608c06ccd6d56b3bee1843458d509c53f9b53dffffe07cc11d8f03fa969"
