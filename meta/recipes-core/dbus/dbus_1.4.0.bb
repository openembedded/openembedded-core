include dbus.inc

PR = "r0"

SRC_URI[md5sum] = "f59618b18d2fb2bd1fce9e1c5a2a3282"
SRC_URI[sha256sum] = "c96d2f86d40e158e2bf405925a0a42cce0533a8466098e2f2238aa1614926652"
