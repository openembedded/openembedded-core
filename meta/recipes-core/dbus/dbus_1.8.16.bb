include dbus.inc

SRC_URI[md5sum] = "020824a38850501e7d6ba8307a7c5ac3"
SRC_URI[sha256sum] = "7f795268efd343ff0498786acb35097564390d40b1b6158daf1b4f742b522b07"
