require dbus-glib.inc

PR = "r0"

SRC_URI[md5sum] = "7c04ba01df6130c2c4e62f73bea0d0d5"
SRC_URI[sha256sum] = "57939e2b567940beb23a52b5f3075743bd25ab203428e1c86f8c773330565737"
