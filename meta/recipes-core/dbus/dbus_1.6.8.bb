include dbus.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "3bf059c7dd5eda5f539a1b7cfe7a14a2"
SRC_URI[sha256sum] = "fc1370ef38abeeb13f55c905ec002e60705fb0bfde3b8d21c8d6eb8056c11bac"
