require dbus-glib.inc

PR = "r1"

SRC_URI[md5sum] = "b595b36890c4f9f8f5d5dec131c495f8"
SRC_URI[sha256sum] = "5a7fd4cf937cdcb7f2eed61341b70ee0f2607450a50db381618598adf60dd40e"
