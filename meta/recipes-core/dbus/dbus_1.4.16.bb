include dbus.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "44a2a10678e7e50460879c3eb4453a65"
SRC_URI[sha256sum] = "1d8ee6262f8cc2148f06578eee522c755ba0896206b3464ca9bdc84f411b29c6"

