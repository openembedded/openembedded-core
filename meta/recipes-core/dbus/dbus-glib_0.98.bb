require dbus-glib.inc

PR = "r0"

SRC_URI[md5sum] = "3f7f117dc7c8d899d9acfdcbf9253fb8"
SRC_URI[sha256sum] = "297c81d6bb8b1c312e9b0ccfe91eb28ec0672756abb64dfb7bbe2b5f1ae5d111"
