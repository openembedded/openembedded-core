require dbus-glib.inc

SRC_URI[md5sum] = "d7cebf1d69445cbd28b4983392145192"
SRC_URI[sha256sum] = "7ce4760cf66c69148f6bd6c92feaabb8812dee30846b24cd0f7395c436d7e825"
