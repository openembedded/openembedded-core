include dbus.inc

SRC_URI[md5sum] = "6be5ef99ae784de9d04589eb067fe038"
SRC_URI[sha256sum] = "10bf87fdb68815edd01d53885101dbcdd80dacad7198912cca61a4fa22dfaf8e"
