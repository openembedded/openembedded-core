include dbus.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "79eca2f2c1894ac347acce128314428b"
SRC_URI[sha256sum] = "103bdcd261a13140730b5fa69f56a98ab5c89ba3f0116ea62fcfd639520d5aaf"
