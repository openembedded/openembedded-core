require dbus-glib.inc


SRC_URI[md5sum] = "f76b8558fd575d0106c3a556eaa49184"
SRC_URI[sha256sum] = "6964ed585bb8149a14ab744b5ded5e77cf71ec5446e6dcc5fcf5eebcc52df29c"
