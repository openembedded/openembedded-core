require dbus-glib.inc

PR = "r0"

SRC_URI[md5sum] = "d33959a9c0c6a158f5ac6d640316e89e"
SRC_URI[sha256sum] = "80ddf7584a659590103817798dd95d7e451d666f385e5e95a83abf85c46d4605"
