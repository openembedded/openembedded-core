include dbus.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ddf18c86fd86ca0d766e18a514e368fd"
SRC_URI[sha256sum] = "5d3e09a831259ca64b15357cfa1c60a5a7ab06ef469d5b82c2308de9cadf1094"

DEFAULT_PREFERENCE = "-1"

