include dbus.inc

SRC_URI[md5sum] = "d6f709bbec0a022a1847c7caec9d6068"
SRC_URI[sha256sum] = "5689f7411165adc953f37974e276a3028db94447c76e8dd92efe910c6d3bae08"
