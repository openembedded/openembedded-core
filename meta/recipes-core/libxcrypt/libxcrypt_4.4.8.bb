require libxcrypt.inc
