require dropbear.inc

SRC_URI[md5sum] = "6b8d901859d9b8a18e2f6bfe0a892a03"
SRC_URI[sha256sum] = "192538ca2a9ee778f12a2e8ddb6f098fa85dcb6457adc1cb40dd94b3c28f4df6"

PR = "r0"
