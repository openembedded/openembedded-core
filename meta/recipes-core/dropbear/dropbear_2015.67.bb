require dropbear.inc

SRC_URI[md5sum] = "e967e320344cd4bfebe321e3ab8514d6"
SRC_URI[sha256sum] = "7e690594645dfde5787065c78a5d2e4d15e288babfa06e140197ce05f698c8e5"
