require dropbear.inc

SRC_URI[md5sum] = "c21a01111aa5015db038c6efdb85717d"
SRC_URI[sha256sum] = "ab3fe2670a517cc0bbe398ff5d15e9ca12cd14f2fc18930a8111ae2baa64ab76"
