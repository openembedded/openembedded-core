require dropbear.inc

SRC_URI[md5sum] = "8d3579bbbfcea48404a3219643076450"
SRC_URI[sha256sum] = "d866189b1d14e15353aeb4feb616f6132a63ea7c25ca8aa12b63a3a397822e55"

PR = "${INC_PR}.0"
