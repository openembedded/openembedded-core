require dropbear.inc

SRC_URI[md5sum] = "0b0a1d9be6a094710d884209562a626c"
SRC_URI[sha256sum] = "62a8cc3df1d0f136d46f50d4f8d92f7ab7ce1addac76b25446b3f6aaf80bf257"

