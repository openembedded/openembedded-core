require dropbear.inc

SRC_URI[md5sum] = "7066bb9a2da708f3ed06314fdc9c47fd"
SRC_URI[sha256sum] = "595992de432ba586a0e7e191bbb1ad587727678bb3e345b018c395b8c55b57ae"
