require dropbear.inc

SRC_URI[md5sum] = "fffa2fec0c887201bed3a3cc6df7fa35"
SRC_URI[sha256sum] = "4c0c52453b4dd96ef79e5968ed3676de008ee0cf133632acae12bbad588681bb"
