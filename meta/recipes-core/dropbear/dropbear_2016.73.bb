require dropbear.inc

SRC_URI += "file://support-out-of-tree-builds.patch"

SRC_URI[md5sum] = "8d6d78ce60ca52350ec04fcbd711ce9b"
SRC_URI[sha256sum] = "5c61a4f69b093b688629cd365be38701485ff63cfb23642dab7a05ad250aefd7"

