require dropbear.inc

SRC_URI[md5sum] = "96226b82725a8cbecad9fc738930d1d2"
SRC_URI[sha256sum] = "9323766d3257699fd7d6e7b282c5a65790864ab32fd09ac73ea3d46c9ca2d681"
