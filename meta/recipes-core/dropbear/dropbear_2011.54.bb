require dropbear.inc

SRC_URI[md5sum] = "ce1e236c4a8df0cb95253defee6716b5"
SRC_URI[sha256sum] = "a5fe60fa9c11e7b0f6a21ef6e86a53ce3d55236548901905070ff1c1716fbf47"

PR = "r0"
