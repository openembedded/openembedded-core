require dropbear.inc

SRC_URI[md5sum] = "ca2c7932a1399cf361f795aaa3843998"
SRC_URI[sha256sum] = "c6656302bbcc54b0a9c361f505822f6994039117ec32d2897ead3364da079ffa"
