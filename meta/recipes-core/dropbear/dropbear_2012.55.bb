require dropbear.inc

SRC_URI[md5sum] = "44836e5a0419ba12557f9ea46880077e"
SRC_URI[sha256sum] = "808df243c61bb60f2f18fa64bca628cbba0918b2a14139f10e6d59d4ac5a17ce"

PR = "r0"
