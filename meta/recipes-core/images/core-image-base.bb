#
# Copyright (C) 2007 OpenedHand Ltd.
#

IMAGE_FEATURES += "apps-console-core"

LICENSE = "MIT"

inherit poky-image
