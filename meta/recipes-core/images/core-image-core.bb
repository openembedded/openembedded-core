DESCRIPTION = "A very basic X11 image with a terminal"

IMAGE_FEATURES += "apps-console-core package-management x11-base"

LICENSE = "MIT"

inherit core-image
