SUMMARY = "Recipe with a non-SPDX license"
DESCRIPTION = "Is licensed with a non-SPDX license to be used for testing"
LICENSE = "FooLicense"
NO_GENERIC_LICENSE[FooLicense] = "LICENSE"

EXCLUDE_FROM_WORLD = "1"
