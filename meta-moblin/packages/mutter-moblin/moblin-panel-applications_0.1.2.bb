require moblin-panel-applications.inc
