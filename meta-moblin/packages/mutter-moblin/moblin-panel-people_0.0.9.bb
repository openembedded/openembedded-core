require moblin-panel-people.inc
