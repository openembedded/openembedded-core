require moblin-panel-status.inc

DEPENDS = "nbtk mutter-moblin dbus-glib clutter-1.0 telepathy-mission-control mojito"
