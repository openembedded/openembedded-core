require moblin-panel-myzone.inc

DEPENDS = "nbtk mutter-moblin gtk+ mojito gconf libjana"
