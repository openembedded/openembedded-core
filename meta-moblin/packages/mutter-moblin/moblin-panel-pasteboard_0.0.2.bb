require moblin-panel-pasteboard.inc
