require mutter-moblin.inc

SRC_URI = "http://download.moblin.org/sources/mutter-moblin/0.43/mutter-moblin-0.43.8.tar.bz2 \
           file://startup-notify.patch;patch=1 \
           file://88mutter-panelapps.sh \
           file://background-tile.png"
