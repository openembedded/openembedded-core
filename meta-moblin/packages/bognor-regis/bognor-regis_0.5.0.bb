require bognor-regis.inc

S = "${WORKDIR}/${PN}-${PV}_20091116"
