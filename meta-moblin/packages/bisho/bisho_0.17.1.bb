require bisho.inc
