require xorg-data-common.inc

DESCRIPTION = "Common X11 Bitmaps"
LICENSE = "MIT"
DEPENDS += "libxmu"
