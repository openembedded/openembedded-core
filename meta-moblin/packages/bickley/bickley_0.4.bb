require bickley.inc

S = "${WORKDIR}/${PN}-${PV}_20091124"
PR = "r1"
