require xorg-app-common.inc
PE = "1"

DEPENDS += " libxkbfile virtual/libx11"
