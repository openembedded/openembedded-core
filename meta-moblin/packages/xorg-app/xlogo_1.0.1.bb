require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw libxprintutil libxp libxrender libxft libxext libxt"
