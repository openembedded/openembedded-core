require xorg-app-common.inc

DESCRIPTION = "magnify parts of the screen"
DEPENDS += " libxaw libxt"
PE = "1"
