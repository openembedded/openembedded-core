require xorg-app-common.inc

DESCRIPTION = "xmessage displays a message or query in a window."
DEPENDS += " libxaw libxt"
PE = "1"
