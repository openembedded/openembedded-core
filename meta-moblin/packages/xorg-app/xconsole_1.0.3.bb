require xorg-app-common.inc
DESCRIPTION = "monitor system console messages with X"
DEPENDS += " libxt"
PE = "1"
