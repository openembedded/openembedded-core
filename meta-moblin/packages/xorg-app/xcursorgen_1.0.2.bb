require xorg-app-common.inc
DESCRIPTION = "create an X cursor file from a collection of PNG images"
DEPENDS += " virtual/libx11 libxcursor libpng"
PE = "1"
