require xorg-app-common.inc
PE = "1"

DESCRIPTION = "a filter for locale and ISO 2022 support on Unicode terminals"

DEPENDS += " zlib virtual/libx11 libfontenc"

