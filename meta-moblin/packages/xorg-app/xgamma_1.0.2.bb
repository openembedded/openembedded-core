require xorg-app-common.inc

DESCRIPTION = "Alter a monitor's gamma correction through the X server"
DEPENDS += " virtual/libx11 libxxf86vm"
PE = "1"
