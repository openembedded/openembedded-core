require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw libxkbfile virtual/libx11"
