require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw libxt"
