require xorg-app-common.inc

DESCRIPTION = "point and click selection of X11 font names"
DEPENDS += " libxaw"
