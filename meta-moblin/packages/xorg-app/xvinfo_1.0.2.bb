require xorg-app-common.inc

DESCRIPTION = "Print out X-Video extension adaptor information"
DEPENDS += " libxv"
PE = "1"
