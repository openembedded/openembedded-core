require xorg-app-common.inc
DESCRIPTION = "analog / digital clock for X"
DEPENDS += " virtual/libx11 libxaw libxrender libxft libxkbfile libxt"
PE = "1"

