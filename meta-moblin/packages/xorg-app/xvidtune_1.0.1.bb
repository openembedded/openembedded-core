require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw libxxf86vm libxt"
