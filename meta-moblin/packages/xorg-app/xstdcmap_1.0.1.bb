require xorg-app-common.inc
PE = "1"

DEPENDS += " libxmu virtual/libx11"
