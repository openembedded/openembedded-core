require xorg-app-common.inc

DESCRIPTION = "print an X window dump"
DEPENDS += " libxmu virtual/libx11"
PE = "1"
