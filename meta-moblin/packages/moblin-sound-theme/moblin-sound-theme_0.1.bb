
SRC_URI = "file://${PN}-${PV}.tar.bz2"
PR = "r0"

inherit autotools

#FILES_${PN} =+ "${datadir}/icons/moblin"
