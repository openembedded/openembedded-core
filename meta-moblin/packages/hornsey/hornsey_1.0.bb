require hornsey.inc

DEPENDS = "clutter-1.0 clutter-gtk-0.10 clutter-gst-0.10 bickley bognor-regis nbtk startup-notification libunique xtst"

S = "${WORKDIR}/${PN}-${PV}_20091116"
