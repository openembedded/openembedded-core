
SRC_URI = "http://folks.o-hand.com/~ebassi/sources/json-glib-0.6.2.tar.gz"
PR = "r0"

DEPENDS = "glib-2.0"

inherit autotools_stage
