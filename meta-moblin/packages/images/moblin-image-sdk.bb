#
# Copyright (C) 2008 Intel Corporation.
#

IMAGE_FEATURES += "apps-console-core ${NETBOOK_IMAGE_FEATURES} tools-debug tools-profile tools-sdk dev-pkgs"

inherit moblin-image
