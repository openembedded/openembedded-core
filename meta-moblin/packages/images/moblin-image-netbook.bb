#
# Copyright (C) 2008 Intel Corporation.
#

IMAGE_FEATURES += "apps-console-core ${NETBOOK_IMAGE_FEATURES}"

inherit moblin-image
