FEEDNAMEPREFIX = "moblin-bleeding"
FEEDURIPREFIX = "output/moblin-incremental-bleeding/ipk/"
EXTRAOPKGCONFIG = "moblin-feed-config-opkg"
