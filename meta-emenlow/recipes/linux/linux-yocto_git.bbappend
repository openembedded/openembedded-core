FILESEXTRAPATHS := "${THISDIR}/${PN}"
COMPATIBLE_MACHINE_emenlow = "emenlow"
WRMACHINE_emenlow  = "emenlow"
