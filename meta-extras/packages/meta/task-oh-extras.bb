PACKAGES = "task-oh-extraapps"
DESCRIPTION = "Extras Tasks for OpenedHand Poky"
MAINTAINER = "Richard Purdie <richard@openedhand.com>"
PR = "r0"

ALLOW_EMPTY = "1"

RDEPENDS_task-oh-extraapps = "\
    madplay \
    mc"
