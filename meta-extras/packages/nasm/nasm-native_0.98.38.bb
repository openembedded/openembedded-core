SECTION = "unknown"
require nasm_${PV}.bb
S = "${WORKDIR}/nasm-${PV}"
inherit native
