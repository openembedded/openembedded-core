require libbonobo.inc

PR = "r0"

SRC_URI += "file://configure-gthread.patch;patch=1"

