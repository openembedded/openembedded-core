#
# Copyright (C) 2007 OpenedHand Ltd.
#

IMAGE_FEATURES += "apps-core apps-pda"

require poky-image.inc

IMAGE_INSTALL += "task-oh-extraapps"
