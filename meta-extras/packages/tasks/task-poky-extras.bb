PACKAGES = "task-poky-extraapps"
DESCRIPTION = "Extras Tasks for OpenedHand Poky"

ALLOW_EMPTY = "1"

RDEPENDS_task-poky-extraapps = "\
    madplay \
    maemo-mapper-nohildon \
    mc"
