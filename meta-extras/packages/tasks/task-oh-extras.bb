PACKAGES = "task-oh-extraapps"
DESCRIPTION = "Extras Tasks for OpenedHand Poky"
PR = "r0"

ALLOW_EMPTY = "1"

RDEPENDS_task-oh-extraapps = "\
    madplay \
    maemo-mapper-nohildon \
    mc"
