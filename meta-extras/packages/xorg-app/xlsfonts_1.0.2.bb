require xorg-app-common.inc

DESCRIPTION = "server font list displayer for X"
DEPENDS += " virtual/libx11"
