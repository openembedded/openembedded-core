require xorg-app-common.inc

DESCRIPTION = "Sets the visual appearance of the X root window"
LICENSE = "MIT"
DEPENDS += "libxmu xbitmaps"
PE = "1"
