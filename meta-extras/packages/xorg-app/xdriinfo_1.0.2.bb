require xorg-app-common.inc
DESCRIPTION = "query configuration information of DRI drivers"
DEPENDS += " virtual/libx11 glproto virtual/libgl"
PE = "1"
