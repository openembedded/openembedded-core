require xorg-app-common.inc
PE = "1"

DESCRIPTION = "a simple program for managing utmp/wtmp entries"

DEPENDS += " virtual/libx11"
